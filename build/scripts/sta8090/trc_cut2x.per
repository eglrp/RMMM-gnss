;SVN Revision: 1901
;
;ARM946e on chip peripherals

config 16. 8.
width 8.

;begin include file ..\common\arm946.ph
;parameters:

width 8.

tree "ID Registers"

rgroup c15:0x0000--0x0000
 line.long 0x0 "MIDR,Identity Code"
  hexmask.long.byte 0x0 24.--31. 0x1 " IMPL  ,Implementer"
  hexmask.long.byte 0x0 20.--23. 0x1 "  SPEC ,Specification Revision"
  hexmask.long.byte 0x0 16.--19. 0x1 "  ARCH ,Architecture Version"
  hexmask.long.word 0x0 4.--15. 0x1 "  PARTNUM ,Part Number"
  hexmask.long.byte 0x0 0.--3. 0x01 "  REV ,Layout Revision"

rgroup c15:0x0100--0x0100
 line.long 0x0 "CTR,Cache Type"
  bitfld.long 0x0 25.--28. " CLASS ,Cache Class" "0,1,2,3,4,5,6,7,8,9,a,b,c,d,e,f"
  bitfld.long 0x0 24. "     H    ,Cache Havardness" "no,yes"
 textline "                 "
  bitfld.long 0x0 18.--21. " DSIZE ,Data Cache Size" "512,1k,2k,4k,8k,16k,32k,64k,128k,256k,512k,1M,2M,4M,8M"
  bitfld.long 0x0 15.--17. "  DASS ,Data Cache Associativity" "dir,2,4,8,16,32,64,128"
  bitfld.long 0x0 14. "  DM ,Data Cache Multiplier Bit" "0,1"
  bitfld.long 0x0 12.--13. "  DLENGTH ,Data Cache Line Length" "2,4,8,16"
 textline "                 "
  bitfld.long 0x0 6.--9. " ISIZE ,Instruction Cache Size" "512,1k,2k,4k,8k,16k,32k,64k,128k,256k,512k,1M,2M,4M,8M"
  bitfld.long 0x0 3.--5. "  IASS ,Instruction Cache Associativity" "dir,2,4,8,16,32,64,128"
  bitfld.long 0x0 2. "  IM ,Instruction Cache Multiplier Bit" "0,1"
  bitfld.long 0x0 0.--1. "  ILENGTH ,Instruction Cache Line Length" "2,4,8,16"

rgroup c15:0x200--0x200
 line.long 0x0 "TCMCFG ,Tightly coupled memory size configuraton"
  bitfld.long 0x0 18.--21. " DTCM , Data TCM size" "0,res,res,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,res,res,res,res"
  bitfld.long 0x0 14. "  DTCM , Data TCM exists" "yes,no"
 textline "                 "
  bitfld.long 0x0 6.--9. " ITCM , Instruction TCM size" "0,res,res,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,res,res,res,res"
  bitfld.long 0x0 2. "  ITCM , Instruction TCM exists" "yes,no"

tree.end

tree "System Configuration and Control"

width 8.

group c15:0x1--0x1
 line.long 0x0 "CR,Control Register"
  bitfld.long 0x0 19. " ILOAD ,Instruction RAM Load Mode" "Disable,Enable"
  bitfld.long 0x0 18. "   IRAM ,Instruction RAM Enable" "Disable,Enable"
 textline "                 "
  bitfld.long 0x0 17. " DLOAD ,Data RAM Load Mode" "Disable,Enable"
  bitfld.long 0x0 16. "   DRAM ,Data RAM Enable" "Disable,Enable"
 textline "                 "
  bitfld.long 0x0 15. " L4 ,Configure Loading TBIT" "Enable,Disable"
  bitfld.long 0x0 14. "  RR ,Round Robin Replacement Strategy for ICache and DCache" "Random,Round robin"
  bitfld.long 0x0 13. "          V  ,Location of Exception Vectors" "0x00000000,0xFFFF0000"
 textline "                 "
  bitfld.long 0x0 12. " I  ,Instruction Cache" "Disable,Enable"
  bitfld.long 0x0 7. "  B  ,Endianism" "Little,Big"
  bitfld.long 0x0 2. "   C  ,Data Cache" "Disable,Enable"
  bitfld.long 0x0 0. "  M  ,MPU" "Disable,Enable"
 textline "                 "

group c15:0x2--0x2
 line.long 0x0 "DCACHE,Data-Cacheable Register"
  bitfld.long 0x0 0x7 " No.7 ,Memory Area No.7 cacheable" "no,yes"
  bitfld.long 0x0 0x6 " No.6 ,Memory Area No.6 cacheable" "no,yes"
  bitfld.long 0x0 0x5 " No.5 ,Memory Area No.5 cacheable" "no,yes"
  bitfld.long 0x0 0x4 " No.4 ,Memory Area No.4 cacheable" "no,yes"
  bitfld.long 0x0 0x3 " No.3 ,Memory Area No.3 cacheable" "no,yes"
  bitfld.long 0x0 0x2 " No.2 ,Memory Area No.2 cacheable" "no,yes"
  bitfld.long 0x0 0x1 " No.1 ,Memory Area No.1 cacheable" "no,yes"
  bitfld.long 0x0 0x0 " No.0 ,Memory Area No.0 cacheable" "no,yes"

group c15:0x102--0x102
 line.long 0x0 "ICACHE,Instruction-Cacheable Register"
  bitfld.long 0x0 0x7 " No.7 ,Memory Area No.7 cacheable" "no,yes"
  bitfld.long 0x0 0x6 " No.6 ,Memory Area No.6 cacheable" "no,yes"
  bitfld.long 0x0 0x5 " No.5 ,Memory Area No.5 cacheable" "no,yes"
  bitfld.long 0x0 0x4 " No.4 ,Memory Area No.4 cacheable" "no,yes"
  bitfld.long 0x0 0x3 " No.3 ,Memory Area No.3 cacheable" "no,yes"
  bitfld.long 0x0 0x2 " No.2 ,Memory Area No.2 cacheable" "no,yes"
  bitfld.long 0x0 0x1 " No.1 ,Memory Area No.1 cacheable" "no,yes"
  bitfld.long 0x0 0x0 " No.0 ,Memory Area No.0 cacheable" "no,yes"

group c15:0x3--0x3
 line.long 0x0 "WRBUF,Write Buffer Control"
  bitfld.long 0x0 0x7 " No.7 ,Memory Area No.7 bufferable" "no,yes"
  bitfld.long 0x0 0x6 " No.6 ,Memory Area No.6 bufferable" "no,yes"
  bitfld.long 0x0 0x5 " No.5 ,Memory Area No.5 bufferable" "no,yes"
  bitfld.long 0x0 0x4 " No.4 ,Memory Area No.4 bufferable" "no,yes"
  bitfld.long 0x0 0x3 " No.3 ,Memory Area No.3 bufferable" "no,yes"
  bitfld.long 0x0 0x2 " No.2 ,Memory Area No.2 bufferable" "no,yes"
  bitfld.long 0x0 0x1 " No.1 ,Memory Area No.1 bufferable" "no,yes"
  bitfld.long 0x0 0x0 " No.0 ,Memory Area No.0 bufferable" "no,yes"
 textline "                 "

group c15:0x05--0x05
 line.long 0x0 "DACCESS,Data Space Protection Register"
  bitfld.long 0x0 0x1C--0x1F " No.7 ,Memory Area No.7 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x18--0x1B " No.6 ,Memory Area No.6 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x14--0x17 " No.5 ,Memory Area No.5 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x10--0x13 " No.4 ,Memory Area No.4 Access Permission" "S:no  U:no ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
 textline "                 "
  bitfld.long 0x0 0xC--0xF " No.3 ,Memory Area No.3 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x8--0xB " No.2 ,Memory Area No.2 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x4--0x7 " No.1 ,Memory Area No.1 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x0--0x3 " No.0 ,Memory Area No.0 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"

group c15:0x105--0x105
 line.long 0x0 "IACCESS,Instruction Space Protection Register"
  bitfld.long 0x0 0x1C--0x1F " No.7 ,Memory Area No.7 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x18--0x1B " No.6 ,Memory Area No.6 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x14--0x17 " No.5 ,Memory Area No.5 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x10--0x13 " No.4 ,Memory Area No.4 Access Permission" "S:no  U:no ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
 textline "                 "
  bitfld.long 0x0 0xC--0xF " No.3 ,Memory Area No.3 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x8--0xB " No.2 ,Memory Area No.2 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x4--0x7 " No.1 ,Memory Area No.1 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
  bitfld.long 0x0 0x0--0x3 " No.0 ,Memory Area No.0 Access Permission" "S:no  U:no   ,S:r/w U:no ,S:r/w U:r  ,S:r/w U:r/w"
 textline "                 "

group c15:0x6--0x6
 line.long 0x0 "REG0,Protection region/size 0"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 0 base"
  bitfld.long 0x0 1.--5. " Size ,Region 0 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 0" "no,yes"

group c15:0x16--0x16
 line.long 0x0 "REG1,Protection region/size 1"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 1 base"
  bitfld.long 0x0 1.--5. " Size ,Region 1 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 1" "no,yes"

group c15:0x26--0x26
 line.long 0x0 "REG2,Protection region/size 2"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 2 base"
  bitfld.long 0x0 1.--5. " Size ,Region 2 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 2" "no,yes"

group c15:0x36--0x36
 line.long 0x0 "REG3,Protection region/size 3"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 3 base"
  bitfld.long 0x0 1.--5. " Size ,Region 3 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 3" "no,yes"

group c15:0x46--0x46
 line.long 0x0 "REG4,Protection region/size 4"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 4 base"
  bitfld.long 0x0 1.--5. " Size ,Region 4 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 4" "no,yes"

group c15:0x56--0x56
 line.long 0x0 "REG5,Protection region/size 5"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 5 base"
  bitfld.long 0x0 1.--5. " Size ,Region 5 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 5" "no,yes"

group c15:0x66--0x66
 line.long 0x0 "REG6,Protection region/size 6"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 6 base"
  bitfld.long 0x0 1.--5. " Size ,Region 6 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 6" "no,yes"

group c15:0x76--0x76
 line.long 0x0 "REG7,Protection region/size 7"
  hexmask.long 0x0 12.--31. 4096. " Base ,Region 7 base"
  bitfld.long 0x0 1.--5. " Size ,Region 7 size" "UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,UNP,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB"
  bitfld.long 0x0 0. " Enable:,Protection Enable 7" "no,yes"

group c15:0x19--0x19
 line.long 0x0 "DTCM,Tightly-Coupled Data Memory Region"
 hexmask.long 0x0 12.--31. 0x1000 " BASE ,Region Base"
 bitfld.long 0x0 1.--5. " SIZE ,Area Size" "-,-,-,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB,-,-,-,-,-,-,-,-"

group c15:0x119--0x119
 line.long 0x0 "ITCM,Tightly-Coupled Instruction Memory Region"
 hexmask.long 0x0 12.--31. 0x1000 " BASE ,Region Base"
 bitfld.long 0x0 1.--5. " SIZE ,Area Size" "-,-,-,4kB,8kB,16kB,32kB,64kB,128kB,256kB,512kB,1MB,2MB,4MB,8MB,16MB,32MB,64MB,128MB,256MB,512MB,1GB,2GB,4GB,-,-,-,-,-,-,-,-"
 textline "                 "

group c15:0x010d--0x010d
 line.long 0x0 "CONTEXT,Context ID"
 textline "                 "

group c15:0xf--0xf
 line.long 0x0 "TSR,Test State Register"
 bitfld.long 0x0 12. " DCSD ,Disable DCache Streaming" "ena,dis"
 bitfld.long 0x0 11. "  ICSD ,Disable ICache Streaming" "ena,dis"
 bitfld.long 0x0 10. "  DCLD ,Disable DCache Linefill" "ena,dis"
 bitfld.long 0x0  9. "  ICLD ,Disable ICache Linefill" "ena,dis"


tree.end

tree "ICEbreaker"

width 8.

group ice:0x0--0x5 "Debug Control"
 line.long 0x0 "DBGCTRL,Debug Control Register"
  bitfld.long 0x0 0x5 " ICE  ,EmbeddedICE Disable" "enabled,disabled"
  bitfld.long 0x0 0x4 " MONITOR ,Monitor Mode Enable" "disabled,enabled"
 textline "                 "
  bitfld.long 0x0 0x3 " STEP ,Single Step" "disabled,enabled"
  bitfld.long 0x0 0x2 " INTDIS  ,Interrupts Disable" "enabled,disabled"
  bitfld.long 0x0 0x1 "  DBGRQ ,Debug Request" "no,yes"
  bitfld.long 0x0 0x0 "  DBGACK ,Debug Acknowledge" "no,yes"
 line.long 0x4 "DBGSTAT,Debug Status Register"
  bitfld.long 0x4 0x6--0x9 " MOE  ,Method of Entry" "no,BP0,BP1,BPsoft,Vector,BPext,WP0,WP1,WPext,AsyncInt,AsyncExt,Reentry,res,res,res,res"
  bitfld.long 0x4 0x5 " IJBIT ,IJBIT" "0,java"
  bitfld.long 0x4 0x4 "  ITBIT ,ITBIT" "0,thumb"
  bitfld.long 0x4 0x3 "  SYSCOMP ,SYSCOMP" "0,1"
  bitfld.long 0x4 0x2 "  IFEN ,Interrupts Enable" "disabled,enabled"
  bitfld.long 0x4 0x1 "  DBGRQ ,Debug Request" "no,yes"
  bitfld.long 0x4 0x0 "  DBGACK ,Debug Acknowledge" "no,yes"
 line.long 0x8 "VECTOR,Vector Catch Register"
  bitfld.long 0x8 0x7 " FIQ  ,FIQ" "dis,ena"
  bitfld.long 0x8 0x6 " IRQ ,IRQ" "dis,ena"
  bitfld.long 0x8 0x4 "  D_ABO ,D_ABORT" "dis,ena"
  bitfld.long 0x8 0x3 "  P_ABO ,P_ABORT" "dis,ena"
  bitfld.long 0x8 0x2 "  SWI ,SWI" "dis,ena"
  bitfld.long 0x8 0x1 "  UND ,UNDEF" "dis,ena"
  bitfld.long 0x8 0x0 "  RES ,RESET" "dis,ena"
 line.long 0x10 "COMCTRL,Debug Communication Control Register"
  bitfld.long 0x10 28.--31. " VERSION ,Version Number" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
  bitfld.long 0x10 0x1 "  WRITE ,Write Register Free" "idle,pend"
  bitfld.long 0x10 0x0 "  READ ,Read Register Free" "idle,pend"
 line.long 0x14 "COMDATA,Debug Communication Data Register"

group ice:0x8--0x0d "Watchpoint 0"
 line.long 0x0 "AV,Address Value"
 line.long 0x4 "AM,Address Mask"
 line.long 0x8 "DV,Data Value"
 line.long 0x0c "DM,Data Mask"
 line.long 0x10 "CV,Control Value"
  bitfld.long 0x10 0x8 " ENABLE ,Global Enable for Watchpoint 1" "DIS,ENA"
  bitfld.long 0x10 0x7 "  RANGE ,Assert RANGEOUT Signal" "0  ,1"
  bitfld.long 0x10 0x6 "  CHAIN ,Connect to Watchpoint 0" "0  ,1"
  bitfld.long 0x10 0x5 "  EXTERN ,Depentend from EXTERN Signal" "0  ,1"
  bitfld.long 0x10 0x4 "  nTRANS ,CPU Mode" "User,no User"
  bitfld.long 0x10 0x3 "  nOPC ,Op Fetch" "Inst,Data"
  bitfld.long 0x10 0x1--0x2 "  MAS ,Access Size" "Byte,Word,Long,Res"
  bitfld.long 0x10 0x0 "  nRW ,Read/Write" "R  ,W"
 line.long 0x14 "CM,Control Mask"
  bitfld.long 0x14 0x7 "             RANGE ,Assert RANGEOUT Signal" "ENA,DIS"
  bitfld.long 0x14 0x6 "  CHAIN ,Connect to Watchpoint 0" "ENA,DIS"
  bitfld.long 0x14 0x5 "  EXTERN ,Depentend from EXTERN Signal" "ENA,DIS"
  bitfld.long 0x14 0x4 "  nTRANS ,CPU Mode" "ENA,DIS    "
  bitfld.long 0x14 0x3 "  nOPC ,Op Fetch" "ENA ,DIS"
  bitfld.long 0x14 0x1--0x2 "  MAS ,Access Size" "ENA ,Res,Res,DIS"
  bitfld.long 0x14 0x0 "  nRW ,Read/Write" "ENA,DIS"

group ice:0x10--0x15 "Watchpoint 1"
 line.long 0x0 "AV,Address Value"
 line.long 0x4 "AM,Address Mask"
 line.long 0x8 "DV,Data Value"
 line.long 0x0c "DM,Data Mask"
 line.long 0x10 "CV,Control Value"
  bitfld.long 0x10 0x8 " ENABLE ,Global Enable for Watchpoint 1" "DIS,ENA"
  bitfld.long 0x10 0x7 "  RANGE ,Assert RANGEOUT Signal" "0  ,1"
  bitfld.long 0x10 0x6 "  CHAIN ,Connect to Watchpoint 0" "0  ,1"
  bitfld.long 0x10 0x5 "  EXTERN ,Depentend from EXTERN Signal" "0  ,1"
  bitfld.long 0x10 0x4 "  nTRANS ,CPU Mode" "User,no User"
  bitfld.long 0x10 0x3 "  nOPC ,Op Fetch" "Inst,Data"
  bitfld.long 0x10 0x1--0x2 "  MAS ,Access Size" "Byte,Word,Long,Res"
  bitfld.long 0x10 0x0 "  nRW ,Read/Write" "R  ,w"
 line.long 0x14 "CM,Control Mask"
  bitfld.long 0x14 0x7 "             RANGE ,Assert RANGEOUT Signal" "ENA,DIS"
  bitfld.long 0x14 0x6 "  CHAIN ,Connect to Watchpoint 0" "ENA,DIS"
  bitfld.long 0x14 0x5 "  EXTERN ,Depentend from EXTERN Signal" "ENA,DIS"
  bitfld.long 0x14 0x4 "  nTRANS ,CPU Mode" "ENA,DIS    "
  bitfld.long 0x14 0x3 "  nOPC ,Op Fetch" "ENA ,DIS"
  bitfld.long 0x14 0x1--0x2 "  MAS ,Access Size" "ENA ,Res,Res,DIS"
  bitfld.long 0x14 0x0 "  nRW ,Read/Write" "ENA,DIS"

tree.end

width 8.

tree "Teseo 3 Peripherals"

group.long sd:0x30003ff8--0x30003ffb
 line.long 0x00 "Info,Informations on STA8089/90"
  bitfld.long         0x00    28.--30.         "  CutVer ,Teseo3 Cut version" "--,AA,AB,BA,BB,BC,--,--"

tree "PRCC (Power Reset Clock Control) Registers"

tree "Main Registers"

width 8.

group.long sd:0x5200f000--0x5200f07f
 line.long 0x00 "ProcSts,Processor Status Register"

 line.long 0x04 "PerSts,Peripheral Status Register"

 line.long 0x10 "ProcCfg,Processor configuration register"
  bitfld.long           0x10   0.             "  INITRAM      ,INITRAM        "                     "DIS,ENA"
  bitfld.long           0x10   1.--4.         "  TCMcfg       ,TCMcfg         "                     "I016_D240,I032_D224,I048_D208,I064_D192,I080_D176,I096_D160,I112_D144,I128_D128"

 line.long 0x14 "PerCfg,Peripherals configuration register"
  bitfld.long           0x14   0.             "  USB1UART0    ,USB1UART0      "                     "UART,USB "
  bitfld.long           0x14   1.--2.         "  USB_ALT      ,USB_ALT        "                     "UART1,CAN1 ,I2C  ,Res  "
 textline "                 "
  bitfld.long           0x14   4.             "  TIMCLKEN0    ,TIMCLKEN0      "                     "DIS,ENA"
  bitfld.long           0x14   5.             "  TIMCLKEN1    ,TIMCLKEN1      "                     "DIS,ENA"
  bitfld.long           0x14   6.             "  TIMCLKEN2    ,TIMCLKEN2      "                     "DIS,ENA"
  bitfld.long           0x14   7.             "  TIMCLKEN3    ,TIMCLKEN3      "                     "DIS,ENA"
 textline "                 "
  bitfld.long           0x14   8.             "  TIMCLKEN0F0  ,TIMCLKEN0F0    "                     "En ,f0 "
  bitfld.long           0x14   9.             "  TIMCLKEN1F0  ,TIMCLKEN1F0    "                     "En ,f0 "
  bitfld.long           0x14  10.             "  TIMCLKEN2F0  ,TIMCLKEN2F0    "                     "En ,f0 "
  bitfld.long           0x14  11.             "  TIMCLKEN3F0  ,TIMCLKEN3F0    "                     "En ,f0 "
 textline "                 "
  bitfld.long           0x14  12.             "  PC1_PRESENT  ,PC1_PRESENT    "                     "No ,Yes"
  bitfld.long           0x14  13.             "  PC2_PRESENT  ,PC2_PRESENT    "                     "No ,Yes"
  bitfld.long           0x14  14.             "  PCWAITN      ,PCWAITN        "                     " 0 , 1 "

 line.long 0x18 "G3aCfg,G3 All RAMs configuration register"
  bitfld.long           0x18   0.             "  GGPS_DIS     ,GGPS_DIS       "                     "G3 ,ARM"

 line.long 0x1c "G3sCfg,G3 Single RAMs configuration register"
  bitfld.long           0x1c   0.             "  GGPS_ACQ_0      ,GGPS_ACQ_0      "                 "G3 ,ARM"
  bitfld.long           0x1c   1.             "  GGPS_ACQ_1      ,GGPS_ACQ_1      "                 "G3 ,ARM"
  bitfld.long           0x1c   2.             "  GGPS_ACQ_2      ,GGPS_ACQ_2      "                 "G3 ,ARM"
  bitfld.long           0x1c   3.             "  GGPS_ACQ_3      ,GGPS_ACQ_3      "                 "G3 ,ARM"
 textline "                 "
  bitfld.long           0x1c   4.             "  GGPS_ACQ_4      ,GGPS_ACQ_4      "                 "G3 ,ARM"
  bitfld.long           0x1c   5.             "  GGPS_ACQ_5      ,GGPS_ACQ_5      "                 "G3 ,ARM"
  bitfld.long           0x1c   6.             "  GGPS_ACQ_6      ,GGPS_ACQ_6      "                 "G3 ,ARM"
  bitfld.long           0x1c   7.             "  GGPS_ACQ_7      ,GGPS_ACQ_7      "                 "G3 ,ARM"
 textline "                 "
  bitfld.long           0x1c   8.             "  GGPS_ACQ_8      ,GGPS_ACQ_8      "                 "G3 ,ARM"
  bitfld.long           0x1c   9.             "  GGPS_ACQ_9      ,GGPS_ACQ_9      "                 "G3 ,ARM"
  bitfld.long           0x1c  10.             "  GGPS_ACQ_10     ,GGPS_ACQ_10     "                 "G3 ,ARM"
  bitfld.long           0x1c  11.             "  GGPS_ACQ_11     ,GGPS_ACQ_11     "                 "G3 ,ARM"
 textline "                 "
  bitfld.long           0x1c  12.             "  GGPS_ACQ_12     ,GGPS_ACQ_12     "                 "G3 ,ARM"
  bitfld.long           0x1c  13.             "  GGPS_ACQ_13     ,GGPS_ACQ_13     "                 "G3 ,ARM"
  bitfld.long           0x1c  14.             "  GGPS_ACQ_14     ,GGPS_ACQ_14     "                 "G3 ,ARM"
  bitfld.long           0x1c  15.             "  GGPS_ACQ_15     ,GGPS_ACQ_15     "                 "G3 ,ARM"

 line.long 0x20 "G3ssCfg,G3 PRN RAMs configuration register"
  bitfld.long           0x20   0.             "  GGPS_RPN_HYST0  ,GGPS_RPN_HYST0  "                 "G3 ,ARM"
  bitfld.long           0x20   1.             "  GGPS_RPN_HYST1  ,GGPS_RPN_HYST0  "                 "G3 ,ARM"
  bitfld.long           0x20   2.             "  GGPS_RPN_HYST2  ,GGPS_RPN_HYST0  "                 "G3 ,ARM"
 textline "                 "
  bitfld.long           0x20   3.             "  GGPS_RPN_HYST3  ,GGPS_RPN_HYST0  "                 "G3 ,ARM"
  bitfld.long           0x20   4.             "  GGPS_RPN_HYST4  ,GGPS_RPN_HYST0  "                 "G3 ,ARM"

 line.long 0x28 "USBStsR,USB status register"
  bitfld.long           0x28   0              "  otg_dppulldown  ,D+ Pull-down resistor enable    " "OFF,ON "
  bitfld.long           0x28   1              "  otg_dmpulldown  ,D+ Pull-down resistor enable    " "OFF,ON "
  bitfld.long           0x28   2              "  otg_ippullup    ,Analog ID input sample enable   " "OFF,ON "
 textline "                 "
  bitfld.long           0x28   3              "  srp_chrgvbus    ,VBUS Input Charge enable        " "OFF,ON "
  bitfld.long           0x28   4              "  srp_dschrgvbus  ,VBUS Input Discharge enable     " "OFF,ON "
  bitfld.long           0x28   5              "  otg_drvvbus     ,Drive VBUS                      " "OFF,ON "

 line.long 0x2c "USBCfgR,USB config register"
  bitfld.long           0x2c   0.             "  utmiotg_iddig   ,Mini A/B plug Indicator         " "OFF,ON "
  bitfld.long           0x2c   1              "  otg_vbusvalid   ,VBUS Valid                      " "OFF,ON "
  bitfld.long           0x2c   2              "  otg_avalid      ,A-peripheral Session Valid      " "OFF,ON "
 textline "                 "
  bitfld.long           0x2c   3              "  otg_bvalid      ,B-peripheral Session Valid      " "OFF,ON "
  bitfld.long           0x2c   4              "  srp_sessend     ,B-device session end            " "OFF,ON "

 line.long 0x40 "REG0 ,PRCC Register 0 "
  bitfld.long           0x40   0.             "  ARM_CLK            ,ARM_CLK           "            "OFF,ON"
  bitfld.long           0x40   1.             "  VIC_CLK            ,VIC_CLK           "            "OFF,ON"
  bitfld.long           0x40   2.             "  SQIO_CLK           ,SQIO_CLK          "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40   3.             "  APB1_CLK           ,APB1_CLK          "            "OFF,ON"
  bitfld.long           0x40   4.             "  GPIO0_CLK          ,GPIO0_CLK         "            "OFF,ON"
  bitfld.long           0x40   5.             "  GPIO1_CLK          ,GPIO1_CLK         "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40   6.             "  APB2_CLK           ,APB2_CLK          "            "OFF,ON"
  bitfld.long           0x40   7.             "  AHB_CLK            ,AHB_CLK           "            "OFF,ON"
  bitfld.long           0x40   8.             "  RTC_CLK            ,RTC_CLK           "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40   9.             "  SRAM_CLK           ,SRAM_CLK          "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  12.             "  USB_CLK            ,USB_CLK           "            "OFF,ON"
  bitfld.long           0x40  13.             "  WDOG_CLK           ,WDOG_CLK          "            "OFF,ON"
  bitfld.long           0x40  14.             "  EFT_CLK            ,EFT_CLK           "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  15.             "  SDMC_CLK           ,SDMC_CLK          "            "OFF,ON"
  bitfld.long           0x40  16.             "  SSP_CLK            ,SSP_CLK           "            "OFF,ON"
  bitfld.long           0x40  17.             "  MTU0_CLK           ,MTU0_CLK          "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  18.             "  MSP_CLK            ,MSP_CLK           "            "OFF,ON"
  bitfld.long           0x40  19.             "  I2C_CLK            ,I2C_CLK           "            "OFF,ON"
  bitfld.long           0x40  20.             "  UART0_CLK          ,UART0_CLK         "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  21.             "  UART1_CLK          ,UART1_CLK         "            "OFF,ON"
  bitfld.long           0x40  22.             "  UART2_CLK          ,UART2_CLK         "            "OFF,ON"
  bitfld.long           0x40  23.             "  CAN0_CLK           ,CAN0_CLK          "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  24.             "  CAN1_CLK           ,CAN1_CLK          "            "OFF,ON"
  bitfld.long           0x40  25.             "  ADC_CLK            ,ADC_CLK           "            "OFF,ON"
  bitfld.long           0x40  26.             "  THS_CLK            ,THS_CLK           "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  27.             "  FSMC_CLK           ,FSMC_CLK          "            "OFF,ON"
  bitfld.long           0x40  28.             "  RIOSC_REF_CLK      ,RIOSC_REF_CLK     "            "OFF,ON"
  bitfld.long           0x40  29.             "  REC_PLAY_CLK       ,REC_PLAY_CLK      "            "OFF,ON"
 textline "                 "
  bitfld.long           0x40  30.             "  TCXO2G3BB_CLK      ,TCXO2G3BB_CLK     "            "OFF,ON"
  bitfld.long           0x40  31.             "  CLK_CTRL_CLK_FSM   ,CLK_CTRL_CLK_FSM  "            "OFF,ON"

 line.long 0x44 "REG1 ,PRCC Register 1 "
  bitfld.long           0x44   0.             "  ARM_RSTN           ,ARM_RSTN          "            "RST,RUN"
  bitfld.long           0x44   1.             "  VIC_RSTN           ,VIC_RSTN          "            "RST,RUN"
  bitfld.long           0x44   2.             "  SQIO_RSTN          ,SQIO_RSTN         "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44   3.             "  APB1_RSTN          ,APB1_RSTN         "            "RST,RUN"
  bitfld.long           0x44   4.             "  GPIO0_RSTN         ,GPIO0_RSTN        "            "RST,RUN"
  bitfld.long           0x44   5.             "  GPIO1_RSTN         ,GPIO1_RSTN        "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44   6.             "  APB2_RSTN          ,APB2_RSTN         "            "RST,RUN"
  bitfld.long           0x44   7.             "  AHB_RSTN           ,AHB_RSTN          "            "RST,RUN"
  bitfld.long           0x44   8.             "  RTC_RSTN           ,RTC_RSTN          "            "RST,RUN"
 textline "                                         "
  bitfld.long           0x44  10.             "  G3_RSTN            ,G3_RSTN           "            "RST,RUN"
  bitfld.long           0x44  11.             "  G3_HRSTN           ,G3_HRSTN          "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  12.             "  USB_RSTN           ,USB_RSTN          "            "RST,RUN"
  bitfld.long           0x44  13.             "  WDOG_RSTN          ,WDOG_RSTN         "            "RST,RUN"
  bitfld.long           0x44  14.             "  EFT_RSTN           ,EFT_RSTN          "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  15.             "  SDMC_RSTN          ,SDMC_RSTN         "            "RST,RUN"
  bitfld.long           0x44  16.             "  SSP_RSTN           ,SSP_RSTN          "            "RST,RUN"
  bitfld.long           0x44  17.             "  MTU0_RSTN          ,MTU0_RSTN         "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  18.             "  MSP_RSTN           ,MSP_RSTN          "            "RST,RUN"
  bitfld.long           0x44  19.             "  I2C_RSTN           ,I2C_RSTN          "            "RST,RUN"
  bitfld.long           0x44  20.             "  UART0_RSTN         ,UART0_RSTN        "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  21.             "  UART1_RSTN         ,UART1_RSTN        "            "RST,RUN"
  bitfld.long           0x44  22.             "  UART2_RSTN         ,UART2_RSTN        "            "RST,RUN"
  bitfld.long           0x44  23.             "  CAN0_RSTN          ,CAN0_RSTN         "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  24.             "  CAN1_RSTN          ,CAN1_RSTN         "            "RST,RUN"
  bitfld.long           0x44  25.             "  ADC_RSTN           ,ADC_RSTN          "            "RST,RUN"
  bitfld.long           0x44  26.             "  THS_RSTN           ,THS_RSTN          "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  27.             "  FSMC_RSTN          ,FSMC_RSTN         "            "RST,RUN"
  bitfld.long           0x44  28.             "  RIOSC_REF_RSTN     ,RIOSC_REF_RSTN    "            "RST,RUN"
  bitfld.long           0x44  29.             "  REC_PLAY_RSTN      ,REC_PLAY_RSTN     "            "RST,RUN"
 textline "                 "
  bitfld.long           0x44  30.             "  TCXO2G3BB_RSTN     ,TCXO2G3BB_RSTN    "            "RST,RUN"
  bitfld.long           0x44  31.             "  CLK_CTRL_RSTN_FSM  ,CLK_CTRL_RSTN_FSM "            "RST,RUN"

 line.long 0x48 "REG2 ,PRCC Register 2 "
  bitfld.long           0x48   5.--6.         "  THSENS_CLK_SEL       ,THSENS_CLK_SEL       "       "  F,F/2,F/4,F/4"
  bitfld.long           0x48   7.             "  THSENS_CLK_SEL_UPD   ,THSENS_CLK_SEL_UPD   "       " OK,UPD"
  bitfld.long           0x48  23.             "  THSENS_CLK_ACK       ,THSENS_CLK_ACK       "       "STP,RUN"
 textline "                 "
  bitfld.long           0x48   8.             "  TCXO_2SMPS_CLK_EN    ,TCXO_2SMPS_CLK_EN    "       "STP,RUN"
  bitfld.long           0x48   9.             "  R64F0_2SMPS_CLK_EN   ,R64F0_2SMPS_CLK_EN   "       "STP,RUN"
 textline "                 "
  bitfld.long           0x48  10.--11.        "  SMPS_CLK_SEL      ,SMPS_CLK_SEL        "           "  TCXO,TCXO/2,TCXO/4,64f0/4"
  bitfld.long           0x48  12.             "  SMPS_CLK_SEL_UPD     ,SMPS_CLK_SEL_UPD     "       " OK,UPD"
  bitfld.long           0x48  13.             "  SMPS_CLK_EN            ,SMPS_CLK_EN        "       "DIS,ENA"
 textline "                 "
  bitfld.long           0x48  16.             "  CLKCTRL_CLK_SEL     ,CLKCTRL_CLK_SEL     "         "OSCI,RING"
  bitfld.long           0x48  18.             "  CLKCTRL_CLK_ACK      ,CLKCTRL_CLK_ACK    "         "STP,RUN"
  bitfld.long           0x48  19.             "  RING_2CLKCTRL_CLK_ACK  ,RING_2CLKCTRL_CLK_ACK  "   "nRNG,RNG "
 textline "                 "
  bitfld.long           0x48  21.             "  MTU1_MTU2_CLK_ACK    ,MTU1_MTU2_CLK_ACK    "       "STP,RUN"
  bitfld.long           0x48  22.             "  R64F0_2SMPS_CLK_ACK  ,R64F0_2SMPS_CLK_ACK  "       "STP,RUN"
  bitfld.long           0x48  20.             "  OSCI_2CLKCTRL_CLK_ACK  ,OSCI_2CLKCTRL_CLK_ACK    " "nOSC,OSC "
 textline "                 "
  bitfld.long           0x48  30.             "  MTU2_RSTN            ,MTU2_RSTN         "          "RST,RUN"
  bitfld.long           0x48  31.             "  MTU2_CLK             ,MTU2_CLK            "        "OFF,ON "
 textline "                 "
  bitfld.long           0x48  27.             "  RING_2ARM_CLK_ACK    ,RING_2ARM_CLK_ACK    "       "STP,RUN"
  bitfld.long           0x48  26.             "  OSCI_2ARM_CLK_ACK    ,OSCI_2ARM_CLK_ACK    "       "STP,RUN"
 textline "                 "
  bitfld.long           0x48  25.             "  TCXO_2ARM_CLK_ACK    ,TCXO_2ARM_CLK_ACK      "     "STP,RUN"
  bitfld.long           0x48  24.             "  R192_2ARM_CLK_ACK    ,R192F0_2ARM_CLK_ACK    "     "STP,RUN"

 line.long 0x4c "REG3 ,PRCC Register 3 "
  bitfld.long           0x4c   0.             "  RING_2ARM_CLK_EN     ,RING_2ARM_CLK_EN      "      "STP,RUN"
  bitfld.long           0x4c   6.             "  OSCI_2ARM_CLK_EN     ,OSCI_2ARM_CLK_EN      "      "STP,RUN"
 textline "                 "
  bitfld.long           0x4c  11.             "  TCXO_2ARM_CLK_EN     ,TCXO_2ARM_CLK_EN      "      "STP,RUN"
  bitfld.long           0x4c  17.             "  R192_2ARM_CLK_EN     ,R192_2ARM_CLK_EN      "      "STP,RUN"
 textline "                 "
  bitfld.long           0x4c   5.             "  RING_CLK_DIV_UPD     ,RING_CLK_DIV_UPD      "      " OK,UPD"
  bitfld.long           0x4c   1.--4.         "  RING_2ARM_CLK_DIV    ,RING_2ARM_CLK_DIV     "      "2,4,8,16,32, 64,128,256,512,1024,2048,4096,8192,16384,32768,65536"
 textline "                 "
  bitfld.long           0x4c  10.             "  OSCI_CLK_DIV_UPD     ,OSCI_CLK_DIV_UPD      "      " OK,UPD"
  bitfld.long           0x4c   7.--9.         "  OSCI_2ARM_CLK_DIV    ,OSCI_2ARM_CLK_DIV     "      "2,4,8,16,32,64,128,256"
 textline "                 "
  bitfld.long           0x4c  16.             "  TCXO_CLK_DIV_UPD     ,TCXO_CLK_DIV_UPD      "      " OK,UPD"
  bitfld.long           0x4c  12.--15.        "  TCXO_2ARM_CLK_DIV    ,TCXO_2ARM_CLK_DIV     "      "2,4,8,16,32, 64,128,256,512,1024,2048,4096,8192,16384,32768,65536"
 textline "                 "
  bitfld.long           0x4c  20.             "  R192_CLK_DIV_UPD     ,R192_CLK_DIV_UPD      "      " OK,UPD"
  bitfld.long           0x4c  18.--19.        "  R192_2ARM_CLK_DIV    ,R192_2ARM_CLK_DIV     "      "OFF,2,3,4"
 textline "                 "
  bitfld.long           0x4c  24.             "  ARM_CLK_SEL_UPD      ,ARM_CLK_SEL_UPD       "      " OK,UPD"
  bitfld.long           0x4c  21.--23.        "  ARM_CLK_SEL          ,ARM_CLK_SEL           "      "192f0,192f0_div,TCXO,TCXO_div,OSCI,OSCI_div,RING,RING_div"
 textline "                 "
  bitfld.long           0x4c  28.             "  HCLKFSMC_CLK_SEL_UPD ,HCLK_AND_FSMC_CLK_SEL_UPD"   " OK,UPD"
  bitfld.long           0x4c  25.--26.        "  HCLK_CLK_SEL         ,HCLK_CLK_SEL          "      "  F,F/2,F/4,F/4"
  bitfld.long           0x4c  27.             "  FSMC_CLK_SEL         ,FSMC_CLK_SEL          "      "  F,2*F"
 textline "                 "
  bitfld.long           0x4c  30.             "  SQIO_CLK_SEL_UPD     ,SQIO_CLK_SEL_UPD      "      " OK,UPD"
  bitfld.long           0x4c  29.             "  SQIO_CLK_SEL         ,SQIO_CLK_SEL          "      "  F,F/2"
 textline "                 "
  bitfld.long           0x4c  31.             "  MSP_FIN_SEL          ,MSP_FIN_SEL           "      "RCK,RFS"

 line.long 0x50 "REG4 ,PRCC Register 4 "
  bitfld.long           0x50   0.             "  PAD_64F0_CLK_EN      ,PAD_64F0_CLK_EN       "      "INT,EXT"
  bitfld.long           0x50   1.             "  PAD_GALGPS_DATA_EN   ,PAD_GALGPS_DATA_EN    "      "INT,EXT"
  bitfld.long           0x50   2.             "  PAD_GNSCOM_DATA_EN   ,PAD_GNSCOM_DATA_EN    "      "INT,EXT"
 textline "                 "
  bitfld.long           0x50   3.             "  REMAP_FSMC_FORCE_EN  ,REMAP_FSMC_FORCE_EN   "      "DIS,ENA"
  bitfld.long           0x50   4.             "  REMAP_FSMC_FRCD_VAL  ,REMAP_FSMC_FORCED_VAL "      "OFF, ON"
 textline "                 "
  bitfld.long           0x50  16.             "  CHIP_EN              ,CHIP_EN               "      "DIS,ENA"
  bitfld.long           0x50  18.             "  RF_BB_EN             ,RF_BB_EN              "      "DIS,ENA"
  bitfld.long           0x50  23.             "  RF_SPI_RESET         ,RF_SPI_RESET          "      "DIS,ENA"
 textline "                 "
  bitfld.long           0x50   5.             "  G3_TBCLK_EN          ,G3_TBCLK_EN           "      "DIS,ENA"
  bitfld.long           0x50   6.             "  G3_RFCLK_GLO_EN      ,G3_RFCLK_GLO_EN       "      "DIS,ENA"
  bitfld.long           0x50   7.             "  G3_RFCLK_EN          ,G3_RFCLK_EN           "      "DIS,ENA"
 textline "                 "
  bitfld.long           0x50   8.             "  G3_CLK32F_EN         ,G3_CLK32F_EN          "      "DIS,ENA"
  bitfld.long           0x50   9.             "  G3_CLK16F_EN         ,G3_CLK16F_EN          "      "DIS,ENA"
  bitfld.long           0x50  10.             "  G3_MCLK_RAMS_EN      ,G3_MCLK_RAMS_EN       "      "DIS,ENA"
 textline "                 "
  bitfld.long           0x50  11.             "  G3_MCLKG3_EN         ,G3_MCLKG3_EN          "      "DIS,ENA"
  bitfld.long           0x50  17.             "  G3CLK_BB_EN          ,G3CLK_BB_EN           "      "DIS,ENA"
 textline "                 "
  bitfld.long           0x50  12.             "  G4RFIP_DISABLE_SPI   ,G4RFIP_DISABLE_SPI    "      "ENA,DIS"
  bitfld.long           0x50  13              "  G4RFIP_SENSE0        ,G4RFIP_SENSE0         "      "  0,  1"
  bitfld.long           0x50  14              "  G4RFIP_SENSE1        ,G4RFIP_SENSE1         "      "  0,  1"
 textline "                 "
  bitfld.long           0x50  15.             "  G4RFIP_ISO_DIS       ,G4RFIP_ISO_DIS        "      "ENA,DIS"
 textline "                 "
  bitfld.long           0x50  20.             "  HM1_ILVDMOK          ,HM1_ILVDMOK           "      "LOW, OK"
  bitfld.long           0x50  26.             "  HM1_SELFREQ          ,HM1_SELFREQ           "      "12M,15M"
  bitfld.long           0x50  27.             "  HM1_CLK_SEL          ,HM1_CLK_SEL           "      "Int,Main"
 textline "                 "
  bitfld.long           0x50  28.             "  HM1_DISABLE_BIG_MOS  ,HM1_DISABLE_BIG_MOS   "      "Nor,Dwn"
  bitfld.long           0x50  29.             "  HM1_PD_ILVDM         ,HM1_PD_ILVDM          "      "ACT, PD"
 textline "                 "
  bitfld.long           0x50  21.             "  HM2_ILVDBOK          ,HM2_ILVDBOK           "      "LOW, OK"
  bitfld.long           0x50  22.             "  HM2_OLVDBOK          ,HM2_OLVDBOK           "      "LOW, OK"
  bitfld.long           0x50  30.             "  HM2_PD_ILVDB         ,HM2_PD_ILVDB          "      "ACT, PD"
 textline "                 "
  bitfld.long           0x50  31.             "  HM2_PD_OLVDB         ,HM2_PD_OLVDB          "      "ACT, PD"
  bitfld.long           0x50  24.--25.        "  CORE_VOLTAGE_SEL     ,CORE_VOLTAGE_SEL      "      "1.1,1.1,1.0,1.2"

 line.long 0x54 "REG5 ,PRCC Register 5 "
  bitfld.long           0x54   0.             "  THS_FSM_ON           ,THS_FSM_ON            "      "BYP,ENA"
  bitfld.long           0x54   1.             "  THS_START            ,THS_START             "      "DIS,ENA"
  hexmask.long.word     0x54   2.--11. 0x1    "  THS_C_CNT_PRESET     ,THS_C_CNT_PRESET      "
 textline "                 "
  bitfld.long           0x54  12.             "  THS_A_PAD_VALUE      ,THS_A_PAD_VALUE       "      "  0,  1"
  bitfld.long           0x54  13.             "  THS_EN               ,THS_EN                "      "IN,OUT"

 line.long 0x58 "REG6 ,PRCC Register 6 "
  bitfld.long           0x58  20.             "  THS_RDY              ,THS_RDY               "      "RUN, OK"
  hexmask.long.tbyte    0x58   0.--19. 0x1    "  THS_CNT_OUT          ,THS_CNT_OUT           "
 textline "                 "
  bitfld.long           0x58  24.             "  THS_UPD_ACK          ,THS_UPD_ACK           "      "RUN, OK"
  hexmask.long.byte     0x58  20.--23. 0x1    "  THS_FSM_STATE        ,THS_FSM_STATE         "

 line.long 0x5c "REG7 ,PRCC Register 7 "
  hexmask.long.tbyte    0x5c   0.--10. 0x1    "  RIOSC_THR_LO      ,RIOSC_THR_LO     "
  hexmask.long.tbyte    0x5c  12.--22. 0x1    "  RIOSC_THR_HI         ,RIOSC_THR_HI        "
 textline "                 "
  hexmask.long.byte     0x5c  24.--28. 0x1    "  RIOSC_TRIM_IN         ,RIOSC_TRIM_IN       "

 line.long 0x60 "REG8 ,PRCC Register 8 "
  bitfld.long           0x60   0.             "  RIOSC_TRIM_EN        ,RIOSC_TRIM_EN     "          "DIS,ENA"
  bitfld.long           0x60   1.             "  RIOSC_FR_MEAS_EN     ,RIOSC_FR_MEAS_EN  "          "DIS,ENA"
  bitfld.long           0x60   2.             "  RIOSC_PD             ,RIOSC_PD          "          "ACT,PD"
 textline "                 "
  bitfld.long           0x60   3.             "  RIOSC_CAL_EN         ,RIOSC_CAL_EN      "          "DIS,ENA"
  bitfld.long           0x60   4.             "  RIOSC_UPDATE         ,RIOSC_UPDATE      "          "OK,UPD"
 textline "                 "
  bitfld.long           0x60  20.             "  RIOSC_ADJ_MIN        ,RIOSC_ADJ_MIN     "          "RUN,MIN"
  bitfld.long           0x60  21.             "  RIOSC_ADJ_MAX        ,RIOSC_ADJ_MAX     "          "RUN,MAX"
  bitfld.long           0x60  22.             "  RIOSC_ADJ_OK         ,RIOSC_ADJ_OK      "          "RUN,OK"

 line.long 0x64 "REG9 ,PRCC Register 9 "
  hexmask.long.tbyte    0x64   0.--12. 0x1    "  RIOSC_FREQ        ,RIOSC_FREQ   "
  hexmask.long.byte     0x64  16.--20. 0x1    "  RIOSC_TRIM_OUT       ,RIOSC_TRIM_OUT   "
 textline "                 "
  hexmask.long.byte     0x64  24.--27. 0x1    "  RIOSC_FSM_STATE       ,RIOSC_FSM_STATE  "

 line.long 0x68 "REG10,PRCC Register 10"
  bitfld.long           0x68   4.             "  TIM2CLKEN0   ,TIM2CLKEN0     "                     "DIS,ENA"
  bitfld.long           0x68   5.             "  TIM2CLKEN1   ,TIM2CLKEN1     "                     "DIS,ENA"
  bitfld.long           0x68   6.             "  TIM2CLKEN2   ,TIM2CLKEN2     "                     "DIS,ENA"
  bitfld.long           0x68   7.             "  TIM2CLKEN3   ,TIM2CLKEN3     "                     "DIS,ENA"
 textline "                 "
  bitfld.long           0x68   8.             "  TIM2CLKEN0F0 ,TIM2CLKEN0F0   "                     "En ,f0 "
  bitfld.long           0x68   9.             "  TIM2CLKEN1F0 ,TIM2CLKEN1F0   "                     "En ,f0 "
  bitfld.long           0x68  10.             "  TIM2CLKEN2F0 ,TIM2CLKEN2F0   "                     "En ,f0 "
  bitfld.long           0x68  11.             "  TIM2CLKEN3F0 ,TIM2CLKEN3F0   "                     "En ,f0 "

 line.long 0x78 "REG14,PRCC Register 14"
  hexmask.long          0x64   0.--31. 0x1    "  TIMEBASE_TCXO   ,TIMEBASE_TCXO"

 line.long 0x7c "REG15,PRCC Register 15"
  bitfld.long           0x7c  16.             "  PIN2PIN             ,PIN2PIN       "               "8090,8089"
  bitfld.long           0x7c  18.             "  POR_CLK_SEL          ,POR_CLK_SEL    "             "RNG,32k"
  bitfld.long           0x7c  19.             "  STARTUP_CLK          ,STARTUP_CLK    "             "OSC,RNG"
 textline "                 "
  bitfld.long           0x7c  20.             "  IORING1_BOOT         ,IORING1_BOOT   "             "1.8,3.3"
  bitfld.long           0x7c  22.             "  IORING3_BOOT         ,IORING3_BOOT   "             "1.8,3.3"
  bitfld.long           0x7c  23.             "  IORING4_BOOT         ,IORING4_BOOT   "             "1.8,3.3"
 textline "                 "
  bitfld.long           0x7c  24.--27.        "  ARM_BOOT            ,ARM_BOOT       "              " ROM,FSMC, ROM, SQI, ROM, ROM, ROM, ROM, ROM, ROM, ROM, ROM, ROM, ROM, ROM, ROM"
  bitfld.long           0x7c  29.             "  BOOT_TEST_MODE       ,BOOT_TEST_MODE "             "ARM,ST"
  bitfld.long           0x7c  30.             "  SQI_SEL              ,SQI_SEL        "             "noBoot,Boot"

tree.end

tree "Backup registers"

group.long sd:0x51000000--0x51000007
 line.long 0x00 "REG0,PRCC Backup Register 0"
  bitfld.long           0x00   0.             "  REMAP_BKRAM       ,REMAP_BKRAM     "                 "OFF,ON"
  bitfld.long           0x00   1.             "  CLOCK_SELECTION_AT_POR  ,CLOCK_SELECTION_AT_POR    " "RNG,32k"
 textline "                 "
  bitfld.long           0x00   2.             "  HM2_OLVDL1OK      ,HM2_OLVDL1OK    "                 "  0,  1"
  bitfld.long           0x00   3.             "  HM1_OLVDMOK       ,HM1_OLVDMOK     "                 "  0,  1"
 textline "                 "
  bitfld.long           0x00  14.             "  HM2_PD_OLVDM      ,HM2_PD_OLVDM    "                 "ACT, PD"
  bitfld.long           0x00  15.             "  HM2_PD_OLVDL1     ,HM2_PD_OLVDL1   "                 "ACT, PD"
  bitfld.long           0x00  16.             "  HM2_PD_BKLDO_CL   ,HM2_PD_BKLDO_CL "                 "ACT, PD"
  bitfld.long           0x00  17.             "  HM2_PD_BKLDO      ,HM2_PD_BKLDO    "                 "ACT, PD"
 textline "                 "
  bitfld.long           0x00  18.             "  HM1_PD            ,HM1_PD          "                 "ACT, PD"
  bitfld.long           0x00  19.             "  HM2_PD_LDO1       ,HM2_PD_LDO1     "                 "ACT, PD"
  bitfld.long           0x00  20.             "  STOP_MODE_ENABLE  ,STOP_MODE_ENABLE"                 "OFF, ON"
  bitfld.long           0x00  21.             "  HM3_EN_LDO2       ,HM3_EN_LDO2     "                 "ACT, PD"
 textline "                 "
  bitfld.long           0x00  24.             "  RTC_RESET_EN      ,RTC_RESET_EN    "                 "ACT,P4R"
  bitfld.long           0x00  25.             "  RTC_CLOCK_EN      ,RTC_CLOCK_EN    "                 "RUN,STP"
  bitfld.long           0x00  26.             "  ARM_SW_RSTN       ,ARM_SW_RSTN     "                 "RUN,RST"
  bitfld.long           0x00  27.             "  STANDBY_EN        ,STANDBY_EN      "                 "DIS,ENA"
 textline "                 "
  bitfld.long           0x00  28.             "  OSCI_EN           ,OSCI_EN         "                 "DIS,ENA"
  bitfld.long           0x00  29.             "  WAKEUP_EN         ,WAKEUP_EN       "                 "DIS,ENA"
  bitfld.long           0x00  30.             "  WAKEUP_RTC_EN     ,WAKEUP_RTC_EN   "                 "DIS,ENA"
  bitfld.long           0x00  31.             "  NO_PRESETN        ,NO_PRESETN      "                 "ENA,DIS"

 line.long 0x04 "REG1,PRCC Backup Register 1"
  bitfld.long           0x04   0.             "  SW_HM2_STANDBY    ,SW_HM2_STANDBY  "                 "DIS,ENA"
  bitfld.long           0x04   1.             "  SW_HM1_STANDBY    ,SW_HM1_STANDBY  "                 "DIS,ENA"
  bitfld.long           0x04   2.             "  SW_STANDBY        ,SW_STANDBY      "                 "---,ENA"
  bitfld.long           0x04   3.             "  PAD_LVD_BY_PU_DIS ,PAD_LVD_BY_PU_DIS"                "nPU, PU"
 textline "                 "
  bitfld.long           0x04   4.             "  WDOG_HW_RST_EN    ,WDOG_HW_RST_EN  "                 "DIS,ENA"
  bitfld.long           0x04   5.             "  EXT_SQI_SEL       ,EXT_SQI_SEL     "                 "DIS,ENA"
  bitfld.long           0x04   6.             "  EXT_SQI_SEL_EN    ,EXT_SQI_SEL_EN  "                 "HWs,SWs"
 textline "                 "
  bitfld.long           0x04  12.             "  WKUP              ,WKUP            "                 "DIS,ENA"
  bitfld.long           0x04  13.             "  WKUP_RTC          ,WKUP_RTC        "                 "DIS,ENA"
  bitfld.long           0x04  14.             "  OSCI_OK           ,OSCI_OK         "                 "RUN, OK"
  bitfld.long           0x04  15.             "  WDOG_RESET        ,WDOG_RESET      "                 "---,OCC"
 textline "                 "
  bitfld.long           0x04  11.             "  LVD_BYPASSN       ,LVD_BYPASSN     "                 " ON,OFF"
  bitfld.long           0x04  10.             "  PMU_CFG          ,PMU_CFG        "                 "SMPS,LDO1"

tree.end

tree.end

tree "Memory"

tree "FSMC"

group.long sd:0x50020000--0x50020007 "Bank 0"
 line.long 0x00 "BCR,Bank Control Register"
  bitfld.long           0x00    0.            "  MBKEN     ,MBKEN     "  "DIS,ENA"
  bitfld.long           0x00    1.            "  MUXEN     ,MUXEN     "  "DIS,ENA"
  bitfld.long           0x00    2.--3.        "  MTYP      ,MTYP      "  "SRAM, -- , NOR, -- "
  bitfld.long           0x00    4.--5.        "  MWID      ,MWID      "  " 8BIT,16BIT,  -- ,  -- "
 textline "                 "
  bitfld.long           0x00    8.            "  BURSTEN   ,BURSTEN   "  "DIS,ENA"
  bitfld.long           0x00    9.            "  WAITPOL   ,WAITPOL   "  "LOW ,HIGH"
  bitfld.long           0x00   11.            "  WAITCFG   ,WAITCFG   "  "OFF,ON"
  bitfld.long           0x00   12.            "  WREN      ,WREN      "  "DIS,ENA"
 textline "                 "
  bitfld.long           0x00   13.            "  BUSTURN   ,BUSTURN   "  "DIS,ENA"
  bitfld.long           0x00   15.            "  WAITASYNC ,WAITASYNC "  "DIS,ENA"

 textline ""

 line.long 0x04 "BTR,Bank Timing Register"
  hexmask.long.byte     0x04    0.--3.    0x1 "  ADDSET   ,ADDSET   "
  hexmask.long.byte     0x04    4.--7.    0x1 "  ADDHLD   ,ADDHLD   "
  hexmask.long.byte     0x04    8.--15.   0x1 "  DATAST   ,DATAST   "
 textline "                 "
  hexmask.long.byte     0x04   16.--19.   0x1 "  BUSTURN  ,BUSTURN  "
  hexmask.long.byte     0x04   20.--23.   0x1 "  CLKDIV   ,CLKDIV   "
  hexmask.long.byte     0x04   24.--27.   0x1 "  DATLAT   ,DATLAT   "

group.long sd:0x50020008--0x5002000f "Bank 1"
  copy

group.long sd:0x50020010--0x50020017 "Bank 2"
  copy

tree.end

tree "SQI"

group.long sd:0x50010000--0x5001010f
 line.long 0x100 "CMDSTREG,Command and status register"
  hexmask.long.byte     0x100   0.--7.    0x1 "  SQIO_CMD      ,SQIO Command"
  bitfld.long           0x100   8.--9.        "  SQIO_MODE      ,SQIO controller mode"          "SPI,QPI,---,QSPI"
  hexmask.long.byte     0x100  12.--14.   0x1 "  CMD_TYPE      ,CMD type register"
 textline "                 "
  hexmask.long.byte     0x100  16.--23.   0x1 "  READ_OPCODE   ,Read opcode"
  hexmask.long.byte     0x100  24.--31.   0x1 "  WR_CNFG_OPCD    ,Write Config opcode"

 line.long 0x104 "ADDR_REG,Address register"
  hexmask.long.byte     0x104  24.--31.   0x1 "  XFER_LEN      ,Transfer length"
  hexmask.long.tbyte    0x104   0.--23.   0x1 "  MEM_ADDR    ,SQIO direct memory address"

 line.long 0x108 "DATA_REG,Data register"

 line.long 0x10c "CFG_REG,Configuration register"
  hexmask.long.byte     0x10c   0.--7.    0x1 "  SPI_CLK_DIV   ,SQIO master clock divider"
  bitfld.long           0x10c   8.            "  MODE        ,SPI Clock Mode"                "Mode 0,Mode 3"
  hexmask.long.byte     0x10c  15.--17.   0x1 "  DUMMY_CYCLES  ,Dummy cycles"
 textline "                 "
  bitfld.long           0x10c  18.            "  DUMMY_DIS    ,Dummy disable"                  " ON,OFF"
  hexmask.long.byte     0x10c  20.--22.   0x1 "  POL_CNT_PRE_SCL ,Dummy cycles"
 textline "                 "
  bitfld.long           0x10c  24.            "  SW_RESET     ,Software Reset"                "---,SET"
  bitfld.long           0x10c  27.            "  INT_EN_POL     ,Polling IRQ enable"            "OFF, ON"
  bitfld.long           0x10c  26.            "  INT_RAWST_POL  ,Raw Polling IRQ status"  "0,1"

tree.end

tree.end

tree "Serial peripherals"

tree "I2C"

group.long sd:0x52007000--0x5200700f "Bank0"
 line.long 0x00 "CR,Control Register"
  bitfld.long           0x00    4.--5.        "  SM        ,Speed mode        "                   "STD,FST,HS ,FM+"
  bitfld.long           0x00    3.            "  SAM       ,Slave addr mode   "                   "7b ,10b"
  bitfld.long           0x00    1.--2.        "  OM        ,Operating Mode    "                   "SLV,MST,MS ,RES"
  bitfld.long           0x00    0.            "  PE        ,Peripheral Enalbe "                   "OFF,ON "
 textline "                 "
  bitfld.long           0x00   12.            "  LM        ,Loopback Mode             "           "OFF,ON "
  bitfld.long           0x00    8.            "  FRX       ,Flush Receive             "           "HW ,SW "
  bitfld.long           0x00    7.            "  FTX       ,Flush Transmit            "           "HW ,SW "
  bitfld.long           0x00    6.            "  SGCM      ,Slave General Call Mode   "           "TM ,DM "
 textline "                 "
  bitfld.long           0x00   15.            "  FS        ,Enable force stop bit               " "OFF,ON "
  bitfld.long           0x00   13.--14.       "  FON       ,Filtering On (filter x ck spikes)   " "OFF,1ck,2ck,4ck"
 line.long 0x04 "SCR,Slave Control Register"
  hexmask.long.word     0x04   16.--31.   0x1 "  SLSU     ,Slave Data Setup Time"
  hexmask.long.byte     0x04    7.--9.    0x1 "  ESA10     ,Ext Slave address"
  hexmask.long.byte     0x04    0.--6.    0x1 "   SA7       ,Slave address"
 line.long 0x08 "HSMCR,High-Speed Master Code Register"
  hexmask.long.byte     0x08    0.--2.    0x1 "  MC         ,Master code"

 line.long 0x0c "MCR,Master Control Register"
  hexmask.long.byte     0x0c    8.--10.   0x1 "  EA10       ,Ext address"
  hexmask.long.byte     0x0c    1.--7.    0x1 "  A7        ,Address"
  bitfld.long           0x0c    0.            "   PE        ,Peripheral Enable "                  "OFF,ON "
 textline "                 "
  hexmask.long.word     0x0c   15.--25.   0x1 "  LENGTH   ,Transaction Length        "
  bitfld.long           0x0c   14.            "  P         ,Stop Condition            "           "RSt,STP"
  bitfld.long           0x0c   12.--13.       "  AM        ,Address type              "           "GC ,7b ,10b,---"
  bitfld.long           0x0c   11.            "  SB        ,Start byte                "           "OFF,ON "

group.long sd:0x52007014--0x52007017 "Bank1"
 line.long 0x00 "SR,Status register"
  bitfld.long         0x00      7.--8.        "  TYPE      ,Receive type      " "FRAME,GCALL,HW_GC,---"
  bitfld.long         0x00      4.--6.        "  CAUSE     ,Abort cause       " "NACK_ADDR,NACK_DATA,ACK_MCODE,ARB_LOST ,BERR_STRT,BERR_STOP,OVERFLOW ,---"
  bitfld.long         0x00      2.--3.        "  STATUS    ,Operating Mode    " "NOP,ONG,OK ,ABT"
  bitfld.long         0x00      0.--1.        "  OP        ,Controller status " "MW ,MR ,RFS,WTS"
 textline "                 "
  hexmask.long.word   0x00      9.--19.   0x1 "  LENGTH    ,Transfer length   "
  bitfld.long         0x00      7.--8.        "   TYPE      ,Receive type      " "FRAME,GCALL,HW_GC,---"

group.long sd:0x5200701c--0x5200705f "Bank2"
 line.long 0x00 "TFTR,Transmit FIFO Thr Register"
 line.long 0x04 "RFTR,Receive FIFO Thr Register"
 line.long 0x0c "BRCR,Baud Rate Counter Register"
  hexmask.long.word   0x0c      0.--15.   0x1 "  BRCNT2 ,Baud Rate Counter 2"
  hexmask.long.word   0x0c     16.--31.   0x1 "  BRCNT1 ,Baud Rate Counter 1"
 line.long 0x10 "IMSCR,Interrupt Mask Set/Clear Register"
  bitfld.long         0x10      3.            "  TXFOM  ,Tx Fifo Overrun Mask           "     "DIS,ENA"
  bitfld.long         0x10      2.            "  TXFFM  ,Tx Fifo Full Mask              "     "DIS,ENA"
  bitfld.long         0x10      1.            "  TXFNEM ,Tx Fifo Nearly Empty Mask      "     "DIS,ENA"
  bitfld.long         0x10      0.            "  TXFEM  ,Tx Fifo Empty Mask             "     "DIS,ENA"
 textline "                 "
  bitfld.long         0x10      6.            "  RXFFM  ,Rx Fifo Full Mask              "     "DIS,ENA"
  bitfld.long         0x10      5.            "  RXFNEM ,Rx Fifo Nearly Empty Mask      "     "DIS,ENA"
  bitfld.long         0x10      4.            "  RXFEM  ,Rx Fifo Empty Mask             "     "DIS,ENA"
 textline "                 "
  bitfld.long         0x10     20.            "  STDM   ,Slave Transaction Done Mask    "     "DIS,ENA"
  bitfld.long         0x10     19.            "  MTDM   ,Master Transaction Done Mask   "     "DIS,ENA"
  bitfld.long         0x10     18.            "  WTSRM  ,Write-to-Slave Request Mask    "     "DIS,ENA"
  bitfld.long         0x10     17.            "  RFSEM  ,Read-from-Slave Empty Mask     "     "DIS,ENA"
  bitfld.long         0x10     16.            "  RFSRM  ,Read-from-Slave Request Mask   "     "DIS,ENA"
 textline "                 "
  bitfld.long         0x10     28.            "  MTDWSM ,Master Transaction Done WS Mask"     "DIS,ENA"
  bitfld.long         0x10     25.            "  BERRM  ,Bus Error Mask                 "     "DIS,ENA"
  bitfld.long         0x10     24.            "  MALM   ,Master Arbitration Lost Mask   "     "DIS,ENA"
 line.long 0x14 "RISR,Raw Interrupt Status Register"
  bitfld.long         0x14      3.            "  TXFO   ,Tx Fifo Overrun RwSt           "     "---,RSD"
  bitfld.long         0x14      2.            "  TXFF   ,Tx Fifo Full RwSt              "     "---,RSD"
  bitfld.long         0x14      1.            "  TXFNE  ,Tx Fifo Nearly Empty RwSt      "     "---,RSD"
  bitfld.long         0x14      0.            "  TXFE   ,Tx Fifo Empty RwSt             "     "---,RSD"
 textline "                 "
  bitfld.long         0x14      6.            "  RXFF   ,Rx Fifo Full RwSt              "     "---,RSD"
  bitfld.long         0x14      5.            "  RXFNE  ,Rx Fifo Nearly Empty RwSt      "     "---,RSD"
  bitfld.long         0x14      4.            "  RXFE   ,Rx Fifo Empty RwSt             "     "---,RSD"
 textline "                 "
  bitfld.long         0x14     20.            "  STD    ,Slave Transaction Done RwSt    "     "---,RSD"
  bitfld.long         0x14     19.            "  MTD    ,Master Transaction Done RwSt   "     "---,RSD"
  bitfld.long         0x14     18.            "  WTSR   ,Write-to-Slave Request RwSt    "     "---,RSD"
  bitfld.long         0x14     17.            "  RFSE   ,Read-from-Slave Empty RwSt     "     "---,RSD"
  bitfld.long         0x14     16.            "  RFSR   ,Read-from-Slave Request RwSt   "     "---,RSD"
 textline "                 "
  bitfld.long         0x14     28.            "  MTDWS  ,Master Transaction Done WS RwSt"     "---,RSD"
  bitfld.long         0x14     25.            "  BERR   ,Bus Error RwSt                 "     "---,RSD"
  bitfld.long         0x14     24.            "  MAL    ,Master Arbitration Lost RwSt   "     "---,RSD"
 line.long 0x18 "MISR,Masked Interrupt MkStus Register"
  bitfld.long         0x18      3.            "  TXFO   ,Tx Fifo Overrun MkSt           "     "---,RSD"
  bitfld.long         0x18      2.            "  TXFF   ,Tx Fifo Full MkSt              "     "---,RSD"
  bitfld.long         0x18      1.            "  TXFNE  ,Tx Fifo Nearly Empty MkSt      "     "---,RSD"
  bitfld.long         0x18      0.            "  TXFE   ,Tx Fifo Empty MkSt             "     "---,RSD"
 textline "                 "
  bitfld.long         0x18      6.            "  RXFF   ,Rx Fifo Full MkSt              "     "---,RSD"
  bitfld.long         0x18      5.            "  RXFNE  ,Rx Fifo Nearly Empty MkSt      "     "---,RSD"
  bitfld.long         0x18      4.            "  RXFE   ,Rx Fifo Empty MkSt             "     "---,RSD"
 textline "                 "
  bitfld.long         0x18     20.            "  STD    ,Slave Transaction Done MkSt    "     "---,RSD"
  bitfld.long         0x18     19.            "  MTD    ,Master Transaction Done MkSt   "     "---,RSD"
  bitfld.long         0x18     18.            "  WTSR   ,Write-to-Slave Request MkSt    "     "---,RSD"
  bitfld.long         0x18     17.            "  RFSE   ,Read-from-Slave Empty MkSt     "     "---,RSD"
  bitfld.long         0x18     16.            "  RFSR   ,Read-from-Slave Request MkSt   "     "---,RSD"
 textline "                 "
  bitfld.long         0x18     28.            "  MTDWS  ,Master Transaction Done WS MkSt"     "---,RSD"
  bitfld.long         0x18     25.            "  BERR   ,Bus Error MkSt                 "     "---,RSD"
  bitfld.long         0x18     24.            "  MAL    ,Master Arbitration Lost MkSt   "     "---,RSD"
 line.long 0x1c "ICR,Interrupt Clear Register"
 line.long 0x2c "DCR,Data Control Register"
 line.long 0x30 "THDDAT,Hold Time Data Register"
 line.long 0x34 "FST_STD,Hold Time Start Condition F/S Register"
 line.long 0x38 "FMP_HS,Hold Time Start Condition FMP/HS Register"
 line.long 0x3c "FST_STD,Setup Time Start Condition F/S Register"
 line.long 0x40 "FMP_HS,I2C Setup Time Start Condition FMP/HS Register"

tree.end

tree "MSP"

group.long sd:0x52006004--0x52006fff
 line.long 0x00 "GCR,Global Configuration Register"
  bitfld.long         0x00     23.            "  SPIBME  ,SPI burst enabled              "      "DIS ,ENA "
  bitfld.long         0x00     21.--22.       "  SPICKM  ,SPI clock mode                 "      "--- ,--- ,ZD  ,HCD "
  bitfld.long         0x00     20.            "  FGEN    ,Frame Generator Enable         "      "DIS ,ENA "
  bitfld.long         0x00     18.--19.       "  SCKSEL  ,Sample Rate Generator Clocl Sel"      "---   ,---   ,FREE  ,RESYNC"
 textline "                 "
  bitfld.long         0x00     17.            "  SCKPOL  ,Sample Rate Generator Clock Pol"      "RIS ,FAL "
  bitfld.long         0x00     16.            "  SGEN    ,Sample Rate Generator Enable   "      "DIS ,ENA "
  bitfld.long         0x00     15.            "  TXDDL   ,Transmit Data Extra Delay      "      "DIS ,ENA "
 textline "                 "
  bitfld.long         0x00     14.            "  TCKSEL  ,Transmit Clock Selection       "      "EXT ,INT "
  bitfld.long         0x00     13.            "  TCKPOL  ,Transmit Clock Polarity        "      "RIS ,FAL "
  bitfld.long         0x00     11.--12.       "  TFSSEL  ,Transmit Frame Sync Selection  "      "--- ,--- ,DR  ,SRG "
  bitfld.long         0x00     10.            "  TFSPOL  ,Transmit Frame Sync Polarity   "      "HIGH, LOW"
 textline "                 "
  bitfld.long         0x00      9.            "  TFFEN   ,Transmit FIFO Enable           "      "DIS ,ENA "
  bitfld.long         0x00      8.            "  TXEN    ,Transmitter Enable             "      "DIS ,ENA "
  bitfld.long         0x00      7.            "  LBM     ,Loopback Mode Enable           "      "DIS ,ENA "
  bitfld.long         0x00      6.            "  RCKSEL  ,Receive Clock Selection        "      "EXT ,INT "
 textline "                 "
  bitfld.long         0x00      5.            "  RCKPOL  ,Receive Clock Polarity         "      "FAL ,RIS "
  bitfld.long         0x00      4.            "  RFSSEL  ,Receive Frame Sync Selection   "      "EXT ,INT "
  bitfld.long         0x00      3.            "  DCM     ,Direct Companding Mode         "      "DIS ,ENA "
 textline "                 "
  bitfld.long         0x00      2.            "  RFSPOL  ,Receive Frame Sync Polarity    "      "HIGH, LOW"
  bitfld.long         0x00      1.            "  RFFEN   ,Receive FIFO Enable            "      "DIS ,ENA "
  bitfld.long         0x00      0.            "  RXEN    ,Receiver Enable                "      "DIS ,ENA "

 line.long 0x04 "TCF,Transmit Configuration Register"
  bitfld.long         0x04     28.--29.       "  TBSWAP  ,Transmit Halfword Swapping     "      "None,WBS ,HWBS,HWS "
  bitfld.long         0x04     27.            "  TP2EN   ,Transmit Phase 2 Enable bit    "      "DIS ,ENA "
  bitfld.long         0x04     26.            "  TP2SM   ,Transmit Phase 2 Start Mode    "      "Ph1 ,FrmS"
  hexmask.long.byte   0x04     19.--25.   0x1 "  TP2FLEN ,Transmit Phase 2 Frame Len     "
 textline "                 "
  bitfld.long         0x04     15.            "  TFSIG   ,Transmit Frame Sync Ignore     "      "DIS ,ENA "
  bitfld.long         0x04     13.--14.       "  TDDLY   ,Transmit Data Delay            "      "0   ,1   ,2   ,3   "
  bitfld.long         0x04     12.            "  TENDN   ,Transmit Bit Endian Format     "      "MSBf,LSBf"
  bitfld.long         0x04     16.--18.       "  TP2ELEN ,Transmit Phase 2 Element Len   "      "8 ,10,12,14,16,20,24,32"
 textline "                 "
  bitfld.long         0x04     10.--11.       "  TDTYP   ,Transmit Data Type             "      "--- ,--- ,uLaw,ALaw"
  bitfld.long         0x04      0.--2.        "  TP1ELEN ,Transmit Phase 1 Element Len   "      "8   ,10,12,14,16,20,24,32"
  hexmask.long.byte   0x04      3.--9.    0x1 "  TP1FLEN ,Transmit Phase 1 Frame Len     "

 line.long 0x08 "RCF,Receive Configuration Register"
  bitfld.long         0x08     28.--29.       "  RBSWAP  ,Receive Halfword Swapping     "       "None,WBS ,HWBS,HWS "
  bitfld.long         0x08     27.            "  RP2EN   ,Receive Phase 2 Enable bit    "       "DIS ,ENA "
  bitfld.long         0x08     26.            "  RP2SM   ,Receive Phase 2 Start Mode    "       "Ph1 ,FrmS"
  hexmask.long.byte   0x08     19.--25.   0x1 "  RP2FLEN ,Receive Phase 2 Frame Len     "
 textline "                 "
  bitfld.long         0x08     15.            "  RFSIG   ,Receive Frame Sync Ignore     "       "DIS ,ENA "
  bitfld.long         0x08     13.--14.       "  RDDLY   ,Receive Data Delay            "       "0   ,1   ,2   ,3   "
  bitfld.long         0x08     12.            "  RENDN   ,Receive Bit Endian Format     "       "MSBf,LSBf"
  bitfld.long         0x08     16.--18.       "  RP2ELEN ,Receive Phase 2 Element Len   "       "8 ,10,12,14,16,20,24,32"
 textline "                 "
  bitfld.long         0x08     10.--11.       "  RDTYP   ,Receive Data Type             "       "--- ,--- ,uLaw,ALaw"
  bitfld.long         0x08      0.--2.        "  RP1ELEN ,Receive Phase 1 Element Len   "       "8   ,10,12,14,16,20,24,32"
  hexmask.long.byte   0x08      3.--9.    0x1 "  RP1FLEN ,Receive Phase 1 Frame Len     "

 line.long 0x0c "SRC,Sample Rate Generator Register"
  hexmask.long.word   0x0c      0.--9.    0x1 "  SCKDIV  ,Divide Factor                 "
  hexmask.long.word   0x0c     16.--28.   0x1 "  FRPER   ,Frame Period                  "
  hexmask.long.byte   0x0c     10.--15.   0x1 "  FRWID   ,Frame Width                   "

 line.long 0x10 "FLR,Flag Register"
  bitfld.long         0x10      5             "  TFU     ,Transmit FIFO Full flag       "       "--- ,RSD"
  bitfld.long         0x10      4             "  TFE     ,Transmit FIFO Empty flag      "       "--- ,RSD"
  bitfld.long         0x10      3             "  TBUSY   ,Transmitter Busy Flag         "       "--- ,RSD"
 textline "                 "
  bitfld.long         0x10      2             "  RFU     ,Receive FIFO Full flag        "       "--- ,RSD"
  bitfld.long         0x10      1             "  RFE     ,Receive FIFO Empty flag       "       "--- ,RSD"
  bitfld.long         0x10      0             "  RBUSY   ,Receiver Busy flag            "       "--- ,RSD"

 line.long 0x1c "IMSC,Interrupt Mask Set/Clear Register"
  bitfld.long         0x1c      9.            "  TFOIM   ,Transmit FIFO not full        "       "DIS ,ENA "
  bitfld.long         0x1c      8.            "  RFOIM   ,Receive FIFO not empty        "       "DIS ,ENA "
  bitfld.long         0x1c      7.            "  TFSIM   ,Transmit Frame Sync           "       "DIS ,ENA "
  bitfld.long         0x1c      6.            "  TSEIM   ,Transmit Frame Sync Error     "       "DIS ,ENA "
 textline "                 "
  bitfld.long         0x1c      5.            "  TUEIM   ,Transmit Underrun Error       "       "DIS ,ENA "
  bitfld.long         0x1c      4.            "  TXIM    ,Transmit                      "       "DIS ,ENA "
  bitfld.long         0x1c      3.            "  RFSIM   ,Receive Frame Sync            "       "DIS ,ENA "
 textline "                 "
  bitfld.long         0x1c      2.            "  RSEIM   ,Receive Frame Sync Error      "       "DIS ,ENA "
  bitfld.long         0x1c      1.            "  ROEIM   ,Receive Overrun Error         "       "DIS ,ENA "
  bitfld.long         0x1c      0.            "  RXIM    ,Receive FIFO Empty flag       "       "DIS ,ENA "

 line.long 0x20 "RIS,Raw Interrupt Status Register"
  bitfld.long         0x20      9             "  TFORIS  ,Transmit FIFO not full        "       "--- ,RSD"
  bitfld.long         0x20      8             "  RFORIS  ,Receive FIFO not empty        "       "--- ,RSD"
  bitfld.long         0x20      7             "  TFSRIS  ,Transmit Frame Sync           "       "--- ,RSD"
  bitfld.long         0x20      6             "  TSERIS  ,Transmit Frame Sync Error     "       "--- ,RSD"
 textline "                 "
  bitfld.long         0x20      5             "  TUERIS  ,Transmit Underrun Error       "       "--- ,RSD"
  bitfld.long         0x20      4             "  TXRIS   ,Transmit                      "       "--- ,RSD"
  bitfld.long         0x20      3             "  RFSRIS  ,Receive Frame Sync            "       "--- ,RSD"
 textline "                 "
  bitfld.long         0x20      2             "  RSERIS  ,Receive Frame Sync Error      "       "--- ,RSD"
  bitfld.long         0x20      1             "  ROERIS  ,Receive Overrun Error         "       "--- ,RSD"
  bitfld.long         0x20      0             "  RXRIS   ,Receive FIFO Empty flag       "       "--- ,RSD"

 line.long 0x24 "RIS,Masked Interrupt Status Register"
  bitfld.long         0x24      9             "  TFOMIS  ,Transmit FIFO not full        "       "--- ,RSD"
  bitfld.long         0x24      8             "  RFOMIS  ,Receive FIFO not empty        "       "--- ,RSD"
  bitfld.long         0x24      7             "  TFSMIS  ,Transmit Frame Sync           "       "--- ,RSD"
  bitfld.long         0x24      6             "  TSEMIS  ,Transmit Frame Sync Error     "       "--- ,RSD"
 textline "                 "
  bitfld.long         0x24      5             "  TUEMIS  ,Transmit Underrun Error       "       "--- ,RSD"
  bitfld.long         0x24      4             "  TXMIS   ,Transmit                      "       "--- ,RSD"
  bitfld.long         0x24      3             "  RFSMIS  ,Receive Frame Sync            "       "--- ,RSD"
 textline "                 "
  bitfld.long         0x24      2             "  RSEMIS  ,Receive Frame Sync Error      "       "--- ,RSD"
  bitfld.long         0x24      1             "  ROEMIS  ,Receive Overrun Error         "       "--- ,RSD"
  bitfld.long         0x24      0             "  RXMIS   ,Receive FIFO Empty flag       "       "--- ,RSD"

 line.long 0x28 "RIS,Masked Interrupt Status Register"
  bitfld.long         0x28      7.            "  TFSIC   ,Transmit Frame Sync           "       "--- ,CLR"
  bitfld.long         0x28      6.            "  TSEIC   ,Transmit Frame Sync Error     "       "--- ,CLR"
  bitfld.long         0x28      5.            "  TUEIC   ,Transmit Underrun Error       "       "--- ,CLR"
  bitfld.long         0x28      3.            "  RFSIC   ,Receive Frame Sync            "       "--- ,CLR"
 textline "                 "
  bitfld.long         0x28      2.            "  RSEIC   ,Receive Frame Sync Error      "       "--- ,CLR"
  bitfld.long         0x28      1.            "  ROEIC   ,Receive Overrun Error         "       "--- ,CLR"
  bitfld.long         0x28      0.            "  RXIC    ,Receive FIFO Empty flag       "       "--- ,CLR"

 line.long 0x2c "MCR,Multichannel Control Register"
  bitfld.long         0x2c      5.            "  TMCEN   ,Transmit MC Mode Enable       "       "DIS ,ENA "
  bitfld.long         0x2c      6.--7.        "  TMCSF   ,Transmit MC Current Subframe  "       "0   ,1   ,2   ,3   "
 textline "                 "
  bitfld.long         0x2c      0.            "  RMCEN   ,Receive MC Mode Enable        "       "DIS ,ENA "
  bitfld.long         0x2c      1.--2.        "  RMCSF   ,Receive MC Current Subframe   "       "0   ,1   ,2   ,3   "
  bitfld.long         0x2c      3.--4.        "  RMCMP   ,Receive MC Comparison Mode    "       "--- ,--- ,RVC0,RVC1"

 line.long 0x30 "RCV,Receive Compare Value Register"

 line.long 0x34 "RCM,Receive Compare Mask Register"

 line.long 0x3c "TCE0,Transmit Channel 0 Enable Register"

 line.long 0x40 "TCE1,Transmit Channel 1 Enable Register"

 line.long 0x44 "TCE2,Transmit Channel 2 Enable Register"

 line.long 0x48 "TCE3,Transmit Channel 3 Enable Register"

 line.long 0x5c "RCE0,Receive Channel 0 Enable Register"

 line.long 0x60 "RCE1,Receive Channel 1 Enable Register"

 line.long 0x64 "RCE2,Receive Channel 2 Enable Register"

 line.long 0x68 "RCE3,Receive Channel 3 Enable Register"

 line.long 0x6c "IODLY,I/O Delay Lines Control Register"
  hexmask.long.byte   0x6c     24.--26.   0x1 "  SCKDLY  ,MSPSCK delay line             "
  hexmask.long.byte   0x6c     20.--22.   0x1 "  RDXDLY  ,MSPRDX delay line             "
  hexmask.long.byte   0x6c     16.--18.   0x1 "  RFSDLY  ,MSPRFS delay line             "
  hexmask.long.byte   0x6c     12.--14.   0x1 "  RCKDLY  ,MSPRCK delay line             "
 textline "                 "
  hexmask.long.byte   0x6c      8.--10.   0x1 "  TDXDLY  ,MSPTDX delay line             "
  hexmask.long.byte   0x6c      4.--6.    0x1 "  TFSDLY  ,MSPTFS delay line             "
  hexmask.long.byte   0x6c      0.--2.    0x1 "  TCKDLY  ,MSPTCK delay line             "

tree.end

tree "SSP"

group.long sd:0x52003000--0x52003007 "Ctrl"
 line.long 0x00 "CR0,Control Register 0"
  bitfld.long         0x00      7.            "  SPH   ,Motorola SPI clock phase"                   " RISING,FALLING"
  bitfld.long         0x00      6.            "  SPO      ,Clock polarity"                          "LOW ,HIGH"
  bitfld.long         0x00      5.            "  HALFDUP  ,Half duplex mode"                        "FULL,HALF"
  bitfld.long         0x00      0.--4.        "  DSS      ,Data size select"                        "RES,RES,RES,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32"
 textline "                 "
  hexmask.long.byte   0x00      8.--15.   0x1 "  SCR      ,Serial clock rate"
  bitfld.long         0x00     16.--20.       "  CSS      ,Command size select"                     "RES,RES,RES,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32"
  bitfld.long         0x00     21.--22.       "  FRF      ,Frame format"                            "Motorola SPI,TI Sync Serial,National Microwire,Unidirectional"
 line.long 0x04 "CR1,Control Register 1"
  bitfld.long         0x04      3.            "  SOD       ,Slave mode output "                     "ENA,DIS"
  bitfld.long         0x04      2.            "  MS        ,Master/slave mode "                     "MST,SLV"
  bitfld.long         0x04      1.            "  SSE       ,SSP Enable        "                     "DIS,ENA"
  bitfld.long         0x04      0.            "  LBM       ,Loopback mode     "                     "OFF,ON "
 textline "                 "
  bitfld.long         0x04      6.            "  MWAIT     ,Microwire Wait State Bit  "             "DIS,ENA"
  bitfld.long         0x04      5.            "  TENDN     ,Transmit Endian Format    "             "MSB,LSB"
  bitfld.long         0x04      4.            "  RENDN     ,Receive Endian Format     "             "MSB,LSB"
 textline "                 "
  bitfld.long         0x04      7.--9.        "  RXIFLSEL  ,Receive Interrupt FIFO Level Select "   "1,4,8,16,RES,RES,RES,RES"
  bitfld.long         0x04     10.--12.       "  TXIFLSEL  ,Transmit Interrupt FIFO Level Select"   "1,4,8,16,RES,RES,RES,RES"

group.long sd:0x5200300c--0x5200301f "Status"
 line.long 0x00 "SR,Status Register"
  bitfld.long         0x00      4             "  BUSYN  ,Busy flag"                                 "F,T"
  bitfld.long         0x00      3             "  RNF    ,Receive FIFO not full"                     "F,T"
  bitfld.long         0x00      2             "  RNE    ,Receive FIFO empty"                        "F,T"
  bitfld.long         0x00      1             "  TNF    ,Transmit FIFO not full"                    "F,T"
  bitfld.long         0x00      0             "  TFE    ,Transmit FIFO empty"                       "F,T"
 line.long 0x04 "CPSR,Clock Prescale Register"
  hexmask.long.byte   0x04      0.--7.    0x1 "  CPSDVSR  ,Clock Prescale divisor"
 line.long 0x08 "IMSC,Interrupt Mask Set/Clear Register"
  bitfld.long         0x08      3             "  TX     ,Transmit interrupt mask"                   "OFF,ON"
  bitfld.long         0x08      2             "  RX     ,Receive interrupt mask"                    "OFF,ON"
  bitfld.long         0x08      1             "  RT     ,Receive Time Out interrupt mask"           "OFF,ON"
  bitfld.long         0x08      0             "  ROR    ,Receive overrun interrupt mask"            "OFF,ON"
 line.long 0x0c "RIS,Raw Interrupt Status Register"
  bitfld.long         0x0c      3             "  TX     ,Transmit raw interrupt status"             "0  ,1  "
  bitfld.long         0x0c      2             "  RX     ,Receive raw interrupt status"              "0  ,1  "
  bitfld.long         0x0c      1             "  RT     ,Receive Time Out raw interrupt status"     "0  ,1  "
  bitfld.long         0x0c      0             "  ROR    ,Receive overrun raw interrupt status"      "0  ,1  "
 line.long 0x10 "MIS,Masked Interrupt Status Register"
  bitfld.long         0x10      3             "  TX     ,Transmit masked interrupt status"          "0  ,1  "
  bitfld.long         0x10      2             "  RX     ,Receive masked interrupt status"           "0  ,1  "
  bitfld.long         0x10      1             "  RT     ,Receive Time Out masked interrupt status"  "0  ,1  "
  bitfld.long         0x10      0             "  ROR    ,Receive overrun masked interrupt status"   "0  ,1  "

tree.end

tree "UARTs"

tree "UART0"

group.long sd:0x5200a004--0x5200afff
 line.long 0x00 "RSR,Receive Status/Error Clear Register"
  bitfld.long         0x00      3             "  OE      ,Overrun Error                   "       "OK ,ERR"
  bitfld.long         0x00      2             "  BE      ,Break Error                     "       "OK ,ERR"
  bitfld.long         0x00      1             "  PE      ,Parity Error                    "       "OK ,ERR"
  bitfld.long         0x00      0             "  FE      ,Frame Error                     "       "OK ,ERR"

 line.long 0x08 "TIMEOUT,Timeout Register"
  hexmask.long.word   0x08      0.--21.   0x1 "  N       ,Timeout Period"

 line.long 0x14 "FR,Flag register"
  bitfld.long         0x14      13            "  RTXDIS  ,Remote Transmitter Disabled     "       "CLR,SET"
  bitfld.long         0x14      9             "  DCTS    ,Delta Clear To Send             "       "CLR,SET"
 textline "                 "
  bitfld.long         0x14      7             "  TXFE    ,Transmit FIFO Empty             "       "CLR,SET"
  bitfld.long         0x14      6             "  RXFF    ,Receive FIFO Full               "       "CLR,SET"
  bitfld.long         0x14      5             "  TXFF    ,Transmit FIFO Full              "       "CLR,SET"
  bitfld.long         0x14      4             "  RXFE    ,Receive FIFO Empty              "       "CLR,SET"
 textline "                 "
  bitfld.long         0x14      3             "  BUSY    ,Busy                            "       "CLR,SET"
  bitfld.long         0x14      2             "  DCD     ,Break Error                     "       "OK ,ERR"
  bitfld.long         0x14      1             "  DSR     ,Parity Error                    "       "OK ,ERR"
  bitfld.long         0x14      0             "  CTS     ,Frame Error                     "       "OK ,ERR"

 line.long 0x18 "LCRH_RX,Receive Line Control Register"
  bitfld.long         0x18      7.            "  SPS     ,Stick parity select             "       "OFF,ON "
  bitfld.long         0x18      4.            "  FEN     ,RX Enable FIFO                  "       "OFF,ON"
  bitfld.long         0x18      5.--6.        "  WLEN    ,RX Word length                  "       "5bits,6bits,7bits,8bits"
 textline "                 "
  bitfld.long         0x18      3.            "  STP2    ,RX Stop bits select             "       " 1b, 2b"
  bitfld.long         0x18      2.            "  EPS     ,RX Parity select                "       "Odd,Evn"
  bitfld.long         0x18      1.            "  PEN     ,RX Parity Enable                "       "OFF, ON"

 line.long 0x20 "IBRD,Integer Baud Rate Register"
  hexmask.long.word   0x20      0.--15.   0x1 "  DIVINT  ,Baud Rate Integer"

 line.long 0x24 "FBRD,Fractional Baud Rate Register"
  hexmask.long.word   0x24      0.--5.    0x1 "  DIVFRAC ,Baud Rate Fraction"

 line.long 0x28 "LCRH_TX,Transmit Line Control Register"
  bitfld.long         0x28      7.            "  SPS     ,Stick parity select             "       "OFF,ON "
  bitfld.long         0x28      4.            "  FEN     ,TX Enable FIFO                  "       "OFF,ON"
  bitfld.long         0x28      5.--6.        "  WLEN    ,TX Word length                  "       "5bits,6bits,7bits,8bits"
 textline "                 "
  bitfld.long         0x28      3.            "  STP2    ,TX Stop bits select             "       " 1b, 2b"
  bitfld.long         0x28      2.            "  EPS     ,TX Parity select                "       "Odd,Evn"
  bitfld.long         0x28      1.            "  PEN     ,TX Parity Enable                "       "OFF, ON"
  bitfld.long         0x28      0.            "  BRK     ,Send Break                      "       "OFF, ON"

 line.long 0x2c "CR,Control Register"
  bitfld.long         0x2c     15.            "  DTSEN   ,CTS HW Flow Control Enable      "       "OFF, ON"
  bitfld.long         0x2c     14.            "  RTSEN   ,RTS HW Flow Control Enable      "       "OFF, ON"
  bitfld.long         0x2c     11.            "  RTS     ,Request To send                 "       "OFF, ON"
  bitfld.long         0x2c     10.            "  DTR     ,Data Transmit Ready             "       "OFF, ON"
 textline "                 "
  bitfld.long         0x2c      9.            "  RXE     ,Receiver enabled                "       "OFF, ON"
  bitfld.long         0x2c      8.            "  TXE     ,Transmitter enabled             "       "OFF, ON"
  bitfld.long         0x2c      7.            "  LBE     ,Loopback enabled                "       "OFF, ON"
  bitfld.long         0x2c      3.            "  OVSFACT ,Oversampling factor             "       " 16,  8"
  bitfld.long         0x2c      0.            "  UARTEN  ,UART enable                     "       "OFF, ON"

 line.long 0x30 "IFLS,Interrupt FIFO Level Register"
  bitfld.long         0x30      3.--5.        "  RX       ,Receive interrupt FIFO Level    "      " 1, 2, 4, 8,16,32,48,--"
  bitfld.long         0x30      0.--2.        "  TX       ,Transmit interrupt FIFO Level   "      " 1, 2, 4, 8,16,32,48,--"

 line.long 0x34 "IMSC,Interrupt Mask Set/Clear Register"
  bitfld.long         0x34      12.           "  TXFEIM  ,TX FIFO Empty Interrupt         "       "DIS,ENA"
  bitfld.long         0x34      11.           "  XOFFIM  ,XOFF Interrupt                  "       "DIS,ENA"
  bitfld.long         0x34      10.           "  OEIM    ,Overrun Error Interrupt         "       "DIS,ENA"
  bitfld.long         0x34      9.            "  BEIM    ,Break Error Interrupt           "       "DIS,ENA"
 textline "                 "
  bitfld.long         0x34      8.            "  PEIM    ,Parity Error Interrupt          "       "DIS,ENA"
  bitfld.long         0x34      7.            "  FEIM    ,Framing Error Interrupt         "       "DIS,ENA"
  bitfld.long         0x34      6.            "  RTIM    ,Receive Timeout Interrupt       "       "DIS,ENA"
  bitfld.long         0x34      5.            "  TXIM    ,Transmit Interrupt              "       "DIS,ENA"
 textline "                 "
  bitfld.long         0x34      4.            "  RXIM    ,Receive Interrupt               "       "DIS,ENA"
  bitfld.long         0x34      1.            "  CTSMIM  ,Clear To Send Modem Interrupt   "       "DIS,ENA"

 line.long 0x38 "RIS,Interrupt Raw Interrupt Register"
  bitfld.long         0x38     12             "  TXFERIS ,TX FIFO Empty Interrupt         "       "---,RSD"
  bitfld.long         0x38     11             "  XOFFRIS ,XOFF Interrupt                  "       "---,RSD"
  bitfld.long         0x38     10             "  OERIS   ,Overrun Error Interrupt         "       "---,RSD"
  bitfld.long         0x38      9             "  BERIS   ,Break Error Interrupt           "       "---,RSD"
 textline "                 "
  bitfld.long         0x38      8             "  PERIS   ,Parity Error Interrupt          "       "---,RSD"
  bitfld.long         0x38      7             "  FERIS   ,Framing Error Interrupt         "       "---,RSD"
  bitfld.long         0x38      6             "  RTRIS   ,Receive Timeout Interrupt       "       "---,RSD"
  bitfld.long         0x38      5             "  TXRIS   ,Transmit Interrupt              "       "---,RSD"
 textline "                 "
  bitfld.long         0x38      4             "  RXRIS   ,Receive Interrupt               "       "---,RSD"
  bitfld.long         0x38      1             "  CTSMRIS ,Clear To Send Modem Interrupt   "       "---,RSD"

 line.long 0x3c "MIS,Interrupt Masked Interrupt Register"
  bitfld.long         0x3c      12            "  TXFEMIS ,TX FIFO Empty Interrupt         "       "---,RSD"
  bitfld.long         0x3c      11            "  XOFFMIS ,XOFF Interrupt                  "       "---,RSD"
  bitfld.long         0x3c      10            "  OEMIS   ,Overrun Error Interrupt         "       "---,RSD"
  bitfld.long         0x3c      9             "  BEMIS   ,Break Error Interrupt           "       "---,RSD"
 textline "                 "
  bitfld.long         0x3c      8             "  PEMIS   ,Parity Error Interrupt          "       "---,RSD"
  bitfld.long         0x3c      7             "  FEMIS   ,Framing Error Interrupt         "       "---,RSD"
  bitfld.long         0x3c      6             "  RTMIS   ,Receive Timeout Interrupt       "       "---,RSD"
  bitfld.long         0x3c      5             "  TXMIS   ,Transmit Interrupt              "       "---,RSD"
 textline "                 "
  bitfld.long         0x3c      4             "  RXMIS   ,Receive Interrupt               "       "---,RSD"
  bitfld.long         0x3c      1             "  CTSMMIS ,Clear To Send Modem Interrupt   "       "---,RSD"

 line.long 0x40 "ICS,Interrupt Interrupt Clear Register"
  bitfld.long         0x40      12.           "  TXFEIC  ,TX FIFO Empty Interrupt         "       "---,CLR"
  bitfld.long         0x40      11.           "  XOFFIC  ,XOFF Interrupt                  "       "---,CLR"
  bitfld.long         0x40      10.           "  OEIC    ,Overrun Error Interrupt         "       "---,CLR"
  bitfld.long         0x40      9.            "  BEIC    ,Break Error Interrupt           "       "---,CLR"
 textline "                 "
  bitfld.long         0x40      8.            "  PEIC    ,Parity Error Interrupt          "       "---,CLR"
  bitfld.long         0x40      7.            "  FEIC    ,Framing Error Interrupt         "       "---,CLR"
  bitfld.long         0x40      6.            "  RTIC    ,Receive Timeout Interrupt       "       "---,CLR"
  bitfld.long         0x40      5.            "  TXIC    ,Transmit Interrupt              "       "---,CLR"
 textline "                 "
  bitfld.long         0x40      4.            "  RXIC    ,Receive Interrupt               "       "---,CLR"
  bitfld.long         0x40      1.            "  CTSMIC  ,Clear To Send Modem Interrupt   "       "---,CLR"

line.long 0x7c "TESTEN,Test enable register"
  bitfld.long         0x7c      0.            "  EN      ,Enable test register            "       "OFF, ON"

line.long 0x84 "TESTvAL,Test value register"
  bitfld.long         0x84      1.            "  RXVAL   ,TX Line status                  "       " 0 , 1 "
  bitfld.long         0x84      0.            "  TXVAL   ,RX Line status                  "       " 0 , 1 "

tree.end

tree "UART1"

group.long sd:0x5200b004--0x5200bfff
  copy

tree.end

tree "UART2"

group.long sd:0x5200c004--0x5200cfff
  copy

tree.end

tree.end

tree "CAN"

tree "CAN0"

group.long sd:0x5200d000--0x5200dfff
 line.long 0x0 "CR,Control Register"
  bitfld.long         0x00     7.             "  Test    ,Test Mode Enable                   " "Normal Operation, Test Mode"
  bitfld.long         0x00     6.             "  CCE     ,Configuration Change Enable        " "DIS,ENA"
  bitfld.long         0x00     5.             "  DAR     ,Disable Automatic Retransmission   " "ON,OFF"
  bitfld.long         0x00     3.             "  EIE     ,Error Interrupt Enable             " "DIS,ENA"
  bitfld.long         0x00     2.             "  SIE     ,Status Change Interrupt Enable     " "DIS,ENA"
  bitfld.long         0x00     1.             "  IE      ,Interrupt Enable                   " "DIS,ENA"
  bitfld.long         0x00     0.             "  Init    ,Initialization                     " "Normal Operation, Init Started"

 line.long 0x4 "SR,Status Register"
  bitfld.long         0x04     7.             "  BOff    ,Busoff Status                      " "OK ,ERR"
  bitfld.long         0x04     6.             "  EWarn   ,Warning Status                     " "OK ,ERR"
  bitfld.long         0x04     5.             "  EPass   ,Error Passive                      " "OK ,ERR"
  bitfld.long         0x04     4.             "  RxOk    ,Received a Message Successfully    " "0 ,1"
  bitfld.long         0x04     3.             "  TxOk    ,Transmitted a Message Successfully " "0 ,1"
  bitfld.long         0x04     0.--2.         "  LEC     ,Last Error Code                    " " NO_Error, STUFF_Error, FORM_Error, ACK_Error, BIT1_Error, BIT0_Error, CRC_Error, Unused"
  textline "                 "

 line.long 0xC "BTR, Bit Timing Register"
  hexmask.long.word   0x0c    12.--14.  0x1   "  TSeg2   ,Time Segment After the sample point  "
  hexmask.long.word   0x0c     8.--11.  0x1   "  TSeg1   ,Time Segment Before the sample point "
  hexmask.long.word   0x0c     6.--7.   0x1   "  SJW     ,Synchronization Jump Width           "
  hexmask.long.word   0x0c     0.--5.   0x1   "  BRP     ,Baud Rate Prescaler                  "

 line.long 0x18 "BRPR, BRP Extension Register"
  hexmask.long.word   0x18     0.--3.   0x1   "  BRPE    ,Baud Rate Prescaler Extension        "
 textline "                 "

 line.long 0x20 "IF1_CRR, IF1 Command Request Register"
  hexmask.long.word   0x20      0.--5.  0x1   "  MsgNum  ,Message number                       "
  bitfld.long         0x20     15.            "  Busy    ,Busy Flag                            " " 0, 1"

 line.long 0x24 "IF1_CMR, IF1 Command Mask Register"
  bitfld.long         0x24      7.            "  WR/RD        ,Write / Read                       " " READ , WRITE"
  bitfld.long         0x24      6.            "  Mask         ,Access Mask Bit                    " " 0 ,1"
  bitfld.long         0x24      5.            "  Arb          ,Access Arbitration Bit             " " 0 ,1"
  bitfld.long         0x24      4.            "  Control      ,Access Control Bit                 " " 0 ,1"
  bitfld.long         0x24      3.            "  ClrIntPnd    ,Clear Interrupt Pending Bit        " " 0, 1"
  bitfld.long         0x24      2.            "  TxReq/NewDat ,Access Transmission Request Bit    " " 0, 1"
  bitfld.long         0x24      1.            "  DataA        ,Data B Access Data Bytes 3:0       " " 0, 1"
  bitfld.long         0x24      0.            "  DataB        ,Data B Access Data Bytes 7:4       " " 0, 1"
 line.long 0x28 "IF1_M1R, IF1 Mask 1 Register"
  hexmask.long.word   0x28      0.--15. 0x1   "  Mask15-0     ,Mask15-0                           "
 line.long 0x2C "IF1_M2R, IF1 Mask 2 Register"
  bitfld.long         0x2C     15.            "  MXtd         ,Mask eXtended Identifier           " " 0, 1"
  bitfld.long         0x2C     14.            "  MDir         ,Mask Message Direction             " " 0, 1"
  hexmask.long.word   0x2C      0.--12. 0x1   "  Mask28-16    ,Mask28-16                       "
 line.long 0x30 "IF1_A1R, IF1 Arbitration 1 Register"
  hexmask.long.word   0x30      0.--15. 0x1   "  ID15-0       ,ID15-0                             "
 line.long 0x34 "IF1_A2R, IF1 Arbitration 2 Register"
  bitfld.long         0x34     15.            "  MsgVal       ,Message Valid                      " " 0, 1"
  bitfld.long         0x34     14.            "  Xtd          ,eXtended Identifier                " " 11-bit ID, 29-bit ID"
  bitfld.long         0x34     13.            "  Dir          ,Direction                          " " RX, TX"
  hexmask.long.word   0x34      0.--12. 0x1   "  ID28-16      ,ID28-16                            "

 line.long 0x38 "IF1_MCR, IF1 Message Control Register"
  bitfld.long         0x38     14.            "  NewDatr      ,New Data                           " " 0, 1"
  bitfld.long         0x38     14.            "  MsgLst       ,Message Lost                       " " 0, 1"
  bitfld.long         0x38     13.            "  IntPnd       ,Interrupt Pending                  " " 0, 1"
  bitfld.long         0x38     12.            "  UMask        ,Use Acceptance Mask                " " 0, 1"
  bitfld.long         0x38     11.            "  TxIE         ,Transmit Interrupt Enable          " " 0, 1"
  bitfld.long         0x38     10.            "  RxIE         ,Receive Interrupt Enable           " " 0, 1"
  bitfld.long         0x38      9.            "  RmtEn        ,Remote Enable                      " " 0, 1"
  bitfld.long         0x38      8.            "  TxRqst       ,Transmit Request                   " " 0, 1"
  bitfld.long         0x38      7.            "  EoB          ,End Of Buffer                      " " 0, 1"
  bitfld.long         0x38      0.--3.        "  DLC3-0       ,Data Lenght Code                   " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15"
 textline "                 "

 line.long 0x80 "IF2_CRR, IF2 Command Request Register"
  hexmask.long.word   0x80      0.--5. 0x1    "  MsgNum  ,Message number                          "
  bitfld.long         0x80     15             "  Busy    ,Busy Flag                               " " 0, 1"

 line.long 0x84 "IF2_CMR, IF2 Command Mask Register"
  bitfld.long         0x84      7.            "  WR/RD        ,Write / Read                       " " READ , WRITE"
  bitfld.long         0x84      6.            "  Mask         ,Access Mask Bit                    " " 0 ,1"
  bitfld.long         0x84      5.            "  Arb          ,Access Arbitration Bit             " " 0 ,1"
  bitfld.long         0x84      4.            "  Control      ,Access Control Bit                 " " 0 ,1"
  bitfld.long         0x84      3.            "  ClrIntPnd    ,Clear Interrupt Pending Bit        " " 0, 1"
  bitfld.long         0x84      2.            "  TxReq/NewDat ,Access Transmission Request Bit    " " 0, 1"
  bitfld.long         0x84      1.            "  DataA        ,Data B Access Data Bytes 3:0       " " 0, 1"
  bitfld.long         0x84      0.            "  DataB        ,Data B Access Data Bytes 7:4       " " 0, 1"
 line.long 0x88 "IF2_M1R, IF2 Mask 1 Register"
  hexmask.long.word   0x88      0.--15. 0x1   "  Mask15-0     ,Mask15-0                           "

 line.long 0x8C "IF2_M2R, IF1 Mask 2 Register"
  bitfld.long         0x8C     15.            "  MXtd         ,Mask eXtended Identifier           " " 0, 1"
  bitfld.long         0x8C     14.            "  MDir         ,Mask Message Direction             " " 0, 1"
  hexmask.long.word   0x8C      0.--12. 0x1   "  Mask28-16    ,Mask28-16                          "

 line.long 0x90 "IF2_A1R, IF2 Arbitration 1 Register"
  hexmask.long.word   0x90      0.--15. 0x1   "  ID15-0       ,ID15-0                             "

 line.long 0x94 "IF2_A2R, IF2 Arbitration 2 Register"
  bitfld.long         0x94     15.            "  MsgVal       ,Message Valid                      " " 0, 1"
  bitfld.long         0x94     14.            "  Xtd          ,eXtended Identifier                " " 11-bit ID, 29-bit ID"
  bitfld.long         0x94     13.            "  Dir          ,Direction                          " " RX, TX"
  hexmask.long.word   0x94      0.--12. 0x1   "  ID28-16      ,ID28-16                            "

 line.long 0x98 "IF2_MCR, IF2 Message Control Register"
  bitfld.long         0x98     15.            "  NewDatr      ,New Data                           " " 0, 1"
  bitfld.long         0x98     14.            "  MsgLst       ,Message Lost                       " " 0, 1"
  bitfld.long         0x98     13.            "  IntPnd       ,Interrupt Pending                  " " 0, 1"
  bitfld.long         0x98     12.            "  UMask        ,Use Acceptance Mask                " " 0, 1"
  bitfld.long         0x98     11.            "  TxIE         ,Transmit Interrupt Enable          " " 0, 1"
  bitfld.long         0x98     10.            "  RxIE         ,Receive Interrupt Enable           " " 0, 1"
  bitfld.long         0x98      9.            "  RmtEn        ,Remote Enable                      " " 0, 1"
  bitfld.long         0x98      8.            "  TxRqst       ,Transmit Request                   " " 0, 1"
  bitfld.long         0x98      7.            "  EoB          ,End Of Buffer                      " " 0, 1"
  bitfld.long         0x98      0.--3.        "  DLC3-0       ,Data Lenght Code                   " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15"
 textline "                 "

tree.end

tree "CAN1"

group.long sd:0x5200e000--0x5200efff
  copy

tree.end

tree.end

tree.end

tree "Timers"

tree "MTU0"

group.long sd:0x52004000--0x5200400f "Common"
 line.long 0x00 "IMSC,Interrupt Mask Set/Clear Register"
  bitfld.long         0x00      3.            "  T3IM  ,Timer 3 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      2.            "  T2IM  ,Timer 2 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      1.            "  T1IM  ,Timer 1 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      0.            "  T0IM  ,Timer 0 Interrupt Mask          "         "DIS,ENA"
 line.long 0x04 "RIS,Raw Interrupt Status Register"
  bitfld.long         0x04      3             "  T3RIS ,Timer 3 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      2             "  T2RIS ,Timer 2 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      1             "  T1RIS ,Timer 1 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      0             "  T0RIS ,Timer 0 Raw Interrupt Status    "         "---,RSD"
 line.long 0x08 "MIS,Masked Interrupt Status Register"
  bitfld.long         0x08      3             "  T3MIS ,Timer 3 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      2             "  T2MIS ,Timer 2 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      1             "  T1MIS ,Timer 1 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      0             "  T0MIS ,Timer 0 Masked Interrupt Status "         "---,RSD"
 line.long 0x0c "ICR,Interrupt Clear Register"
  bitfld.long         0x0c      3.            "  T3IC  ,Timer 3 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      2.            "  T2IC  ,Timer 2 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      1.            "  T1IC  ,Timer 1 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      0.            "  T0IC  ,Timer 0 Interrupt Clear         "         "  0,CLR"

group.long sd:0x52004010--0x5200401f "Timer0"
 line.long 0x00 "LR,Load Value Register"
 line.long 0x04 "VAL,Value Register"
 line.long 0x08 "CR,Control Register"
  bitfld.long         0x08      7.            "  T0EN  ,Enable         "                          "Off,On"
  bitfld.long         0x08      6.            "  T0MOD ,Mode           "                          "FREE,PRDC"
  bitfld.long         0x08      2.--3.        "  T0PRE ,Prescaler      "                          "HCLK/1  ,HCLK/16 ,HCLK/256,UNDEF   "
  bitfld.long         0x08      1.            "  T0SZ  ,Size           "                          "16,32"
  bitfld.long         0x08      0.            "  T0OS  ,One shout count"                          "WRP,1SH"
 line.long 0x0c "T0BGLR,Timer 0 Background Load Value Register"

group.long sd:0x52004020--0x5200402f "Timer1"
  copy

group.long sd:0x52004030--0x5200403f "Timer2"
  copy

group.long sd:0x52004040--0x5200404f "Timer3"
  copy

tree.end

tree "MTU1"

group.long sd:0x52014000--0x5201400f "Common"
 line.long 0x00 "IMSC,Interrupt Mask Set/Clear Register"
  bitfld.long         0x00      3.            "  T3IM  ,Timer 3 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      2.            "  T2IM  ,Timer 2 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      1.            "  T1IM  ,Timer 1 Interrupt Mask          "         "DIS,ENA"
  bitfld.long         0x00      0.            "  T0IM  ,Timer 0 Interrupt Mask          "         "DIS,ENA"
 line.long 0x04 "RIS,Raw Interrupt Status Register"
  bitfld.long         0x04      3             "  T3RIS ,Timer 3 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      2             "  T2RIS ,Timer 2 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      1             "  T1RIS ,Timer 1 Raw Interrupt Status    "         "---,RSD"
  bitfld.long         0x04      0             "  T0RIS ,Timer 0 Raw Interrupt Status    "         "---,RSD"
 line.long 0x08 "MIS,Masked Interrupt Status Register"
  bitfld.long         0x08      3             "  T3MIS ,Timer 3 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      2             "  T2MIS ,Timer 2 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      1             "  T1MIS ,Timer 1 Masked Interrupt Status "         "---,RSD"
  bitfld.long         0x08      0             "  T0MIS ,Timer 0 Masked Interrupt Status "         "---,RSD"
 line.long 0x0c "ICR,Interrupt Clear Register"
  bitfld.long         0x0c      3.            "  T3IC  ,Timer 3 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      2.            "  T2IC  ,Timer 2 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      1.            "  T1IC  ,Timer 1 Interrupt Clear         "         "  0,CLR"
  bitfld.long         0x0c      0.            "  T0IC  ,Timer 0 Interrupt Clear         "         "  0,CLR"

group.long sd:0x52014010--0x5201401f "Timer0"
 line.long 0x00 "LR,Load Value Register"
 line.long 0x04 "VAL,Value Register"
 line.long 0x08 "CR,Control Register"
  bitfld.long         0x08      7.            "  T0EN  ,Enable         "                          "Off,On"
  bitfld.long         0x08      6.            "  T0MOD ,Mode           "                          "FREE,PRDC"
  bitfld.long         0x08      2.--3.        "  T0PRE ,Prescaler      "                          "HCLK/1  ,HCLK/16 ,HCLK/256,UNDEF   "
  bitfld.long         0x08      1.            "  T0SZ  ,Size           "                          "16,32"
  bitfld.long         0x08      0.            "  T0OS  ,One shout count"                          "WRP,1SH"
 line.long 0x0c "T0BGLR,Timer 0 Background Load Value Register"

group.long sd:0x52014020--0x5201402f "Timer1"
  copy

group.long sd:0x52014030--0x5201403f "Timer2"
  copy

group.long sd:0x52014040--0x5201404f "Timer3"
  copy

tree.end

tree "EFT"

group.long sd:0x52001000--0x5200101f
 line.long 0x00 "TIM_ICAR,Input Capture A Register"
 line.long 0x04 "TIM_ICBR,Input Capture B Register"
 line.long 0x08 "TIM_OCAR,Output Capture A Register"
 line.long 0x0c "TIM_OCBR,Output Capture B Register"
 line.long 0x10 "TIM_CNTR,Counter Register"
 line.long 0x14 "TIM_CR1,Control Register 1"
  bitfld.long         0x14     15.            "  EN     ,Timer count enable"                      "OFF,ON"
  bitfld.long         0x14     14.            "  PWMI   ,Pulse width modulation input"            "OFF,ON"
  bitfld.long         0x14     11.            "  FOLVB  ,Force OLVLB to be copied to OCMPB"       "OFF,ON"
  bitfld.long         0x14     10.            "  FOLVA  ,Force OLVLA to be copied to OCMPA"       "OFF,ON"
 textline "                 "
  bitfld.long         0x14     9.             "  OLVLB  ,Output level B"                          "OFF,ON"
  bitfld.long         0x14     8.             "  OLVLA  ,Output level A"                          "OFF,ON"
  bitfld.long         0x14     7.             "  OCBE  ,Output compare B enable"                 "GPIO,TMR "
  bitfld.long         0x14     6.             "  OCAE  ,Output compare A enable"                 "GPIO,TMR "
 textline "                 "
  bitfld.long         0x14     5.             "  OPM    ,One pulse mode"                          "OFF,ON"
  bitfld.long         0x14     4.             "  PWM    ,Pulse width modulation"                  "OFF,ON"
  bitfld.long         0x14     3.             "  IEDGB  ,Input edge B"                            "FAL,RIS"
  bitfld.long         0x14     2.             "  IEDGA  ,Input edge A"                            "FAL,RIS"
 textline "                 "
  bitfld.long         0x14     1.             "  EXEDG  ,External clock edge"                     "FAL,RIS"
  bitfld.long         0x14     0.             "  ECKEN  ,External clock enable"                   "OFF,ON"
 line.long 0x18 "TIM_CR2,Control Register 2"
  bitfld.long         0x18     15.            "  ICAIE  ,Input Capture A IRQ enable"              "OFF,ON"
  bitfld.long         0x18     14.            "  OCAIE  ,Output Capture A IRQ enable"             "OFF,ON"
  bitfld.long         0x18     13.            "  TOIE   ,Timer overflow IRQ enable"               "OFF,ON"
 textline "                 "
  bitfld.long         0x18     12.            "  ICBIE  ,Input Capture B IRQ enable"              "OFF,ON"
  bitfld.long         0x18     11.            "  OCBIE  ,Output Capture B IRQ enable"             "OFF,ON"
 textline "                 "
  hexmask.long.word   0x18      0.--7.    0x1 "  CC      ,Prescaler division factor"
 line.long 0x1c "TIM_SR,Status Register"
  bitfld.long         0x1c     15.            "  ICFA   ,Input Capture A flag"                  "OFF,ON"
  bitfld.long         0x1c     14.            "  OCFA   ,Output Capture A flag"                 "OFF,ON"
  bitfld.long         0x1c     13.            "  TOF    ,Timer overflow flag"                   "OFF,ON"
 textline "                 "
  bitfld.long         0x1c     12.            "  ICFB   ,Input Capture B flag"                  "OFF,ON"
  bitfld.long         0x1c     11.            "  OCFB   ,Output Capture B flag"                 "OFF,ON"

tree.end

tree "RTC"

group.long sd:0x51001000--0x510010ff
 line.long 0x04 "MR,Match Register"
 line.long 0x0c "TCR,Trim and Control Register"
  bitfld.long         0x0c     26.            "  RTCEN    ,Counter Enable bit"                    "OFF,ON"
  hexmask.long.word   0x0c     16.--25.   0x1 "  CKDEL   ,Trim Delete Count"
  hexmask.long.word   0x0c      0.--15.   0x1 "  DIVINT  ,Clock Divider Factor"
 line.long 0x10 "IMSC,Interrupt Mask Register"
  bitfld.long         0x10      0.            "  RTCIMSC  ,RTT Interrupt Enable bit"              "DIS,ENA"
  bitfld.long         0x10      1.            "  RTTIMSC  ,RTC Interrupt Enable bit"              "DIS,ENA"
 line.long 0x14 "RIS,Raw Interrupt Status Register"
  bitfld.long         0x14      0.            "  RTCRIS   ,RTT Raw Interrupt Status bit"          "---,RSD"
  bitfld.long         0x14      1.            "  RTTRIS   ,RTC Raw Interrupt Status bit"          "---,RSD"
 line.long 0x18 "MIS,Masked Interrupt Status Register"
  bitfld.long         0x18      0.            "  RTCMIS   ,RTT Masked Interrupt Status bit"       "---,RSD"
  bitfld.long         0x18      1.            "  RTTMIS   ,RTC Masked Interrupt Status bit"       "---,RSD"
 line.long 0x1c "ICR,Interrupt Clear Register"
  bitfld.long         0x1c      0.            "  RTCMIS   ,RTT Interrupt Clear bit"               "  0,CLR"
  bitfld.long         0x1c      1.            "  RTTMIS   ,RTC Interrupt Clear bit"               "  0,CLR"
 line.long 0x80 "CCR,Counter Control Register"
  bitfld.long         0x80      3.            "  CNTDIS   ,Counter disable"                       "RUN,STP"
  bitfld.long         0x80      4.            "  CNTLOAD ,RTT Interrupt Clear bit"                "----,LOAD"
 line.long 0x90 "RTC_DRI,RTC Integer Data Register"
 line.long 0x94 "RTC_DRF,RTC Fractional Data Register"
 line.long 0x20 "RTT_DR,RTT Data Register"
 line.long 0x24 "RTT_LR,RTT Data Register"
 line.long 0x28 "RTT_CR,Counter Control Register"
  bitfld.long         0x28      0.            "  RTTOS    ,RTT One Shot Count"                    "WRP,1SH"
  bitfld.long         0x28      1.            "  RTTEN    ,RTT Enable bit"                        "OFF,ON"

tree.end

tree.end

tree "WDG"

group.long sd:0x52000000--0x5200001f
 line.long 0x00 "CR,Control Register"
  bitfld.long         0x00      2.            "  EE    ,Enable external clock           "         "DIS,ENA"
  bitfld.long         0x00      1.            "  SC    ,Start counter                   "         "DIS,ENA"
  bitfld.long         0x00      0.            "  WE    ,Watchdog mode                   "         "TIMER,WDG"

 line.long 0x04 "PR,Prescaler Register"
  hexmask.long.word   0x04      0.--7.    0x1 "  PR    ,Prescaler value                 "

 line.long 0x08 "VR,Preload Value Register"
  hexmask.long.word   0x08      0.--15.   0x1 "  TV    ,Preload value                   "

 line.long 0x0c "CR,Counter Register"
  hexmask.long.word   0x0c      0--15     0x1 "  CNT   ,Counter value                   "

 line.long 0x10 "SR,Status Register"
  bitfld.long         0x10      0.            "  EC    ,End of count                    "         "---,RSD"

 line.long 0x14 "MR,Mask Register"
  bitfld.long         0x14      0.            "  ECM   ,End of count mask bit           "         "DIS,ENA"

 line.long 0x18 "KR,Key Register"
  hexmask.long.word   0x18      0--15     0x1 "  K     ,Key value                       "

tree.end

tree "GPIO"

group.long sd:0x52008000--0x5200804f "GPIO port 0"
 line.long 0x00 "DAT  ,GPIO Data Register"
  bitfld.long        0x00      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x00      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x00      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x00      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x00      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x00      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x00      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x00      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x00      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x00      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x00     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x00     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x00     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x00     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x00     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x00     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x00     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x00     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x00     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x00     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x00     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x00     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x00     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x00     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x00     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x00     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x00     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x00     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x00     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x00     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x00     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x00     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x04 "DATS ,GPIO Set Register"
  bitfld.long        0x04      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x04      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x04      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x04      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x04      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x04      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x04      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x04      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x04      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x04      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x04     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x04     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x04     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x04     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x04     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x04     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x04     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x04     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x04     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x04     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x04     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x04     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x04     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x04     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x04     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x04     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x04     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x04     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x04     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x04     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x04     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x04     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x08 "DATC ,GPIO Clear Register"
  bitfld.long        0x08      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x08      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x08      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x08      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x08      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x08      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x08      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x08      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x08      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x08      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x08     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x08     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x08     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x08     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x08     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x08     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x08     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x08     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x08     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x08     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x08     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x08     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x08     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x08     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x08     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x08     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x08     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x08     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x08     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x08     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x08     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x08     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x0c "PDIS ,GPIO Pull Disable Register"
  bitfld.long        0x0c      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x0c      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x0c      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x0c      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x0c      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x0c      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x0c      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x0c      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x0c      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x0c      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x0c     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x0c     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x0c     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x0c     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x0c     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x0c     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x0c     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x0c     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x0c     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x0c     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x0c     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x0c     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x0c     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x0c     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x0c     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x0c     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x0c     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x0c     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x0c     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x0c     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x0c     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x0c     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x10 "DIR  ,GPIO Direction Register"
  bitfld.long        0x10      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x10      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x10      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x10      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x10      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x10      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x10      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x10      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x10      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x10      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x10     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x10     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x10     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x10     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x10     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x10     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x10     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x10     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x10     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x10     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x10     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x10     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x10     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x10     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x10     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x10     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x10     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x10     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x10     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x10     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x10     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x10     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x14 "DIRS ,GPIO Direction Set Register"
  bitfld.long        0x14      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x14      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x14      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x14      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x14      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x14      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x14      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x14      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x14      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x14      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x14     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x14     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x14     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x14     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x14     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x14     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x14     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x14     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x14     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x14     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x14     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x14     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x14     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x14     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x14     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x14     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x14     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x14     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x14     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x14     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x14     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x14     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x18 "DIRC ,GPIO Direction Clear Register"
  bitfld.long        0x18      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x18      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x18      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x18      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x18      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x18      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x18      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x18      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x18      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x18      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x18     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x18     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x18     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x18     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x18     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x18     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x18     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x18     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x18     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x18     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x18     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x18     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x18     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x18     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x18     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x18     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x18     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x18     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x18     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x18     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x18     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x18     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x20 "AFSLA,GPIO Alternate Function Select A"
  bitfld.long        0x20      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x20      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x20      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x20      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x20      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x20      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x20      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x20      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x20      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x20      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x20     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x20     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x20     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x20     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x20     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x20     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x20     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x20     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x20     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x20     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x20     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x20     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x20     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x20     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x20     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x20     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x20     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x20     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x20     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x20     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x20     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x20     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x24 "AFSLB,GPIO Alternate Function Select B"
  bitfld.long        0x24      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x24      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x24      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x24      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x24      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x24      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x24      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x24      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x24      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x24      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x24     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x24     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x24     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x24     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x24     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x24     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x24     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x24     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x24     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x24     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x24     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x24     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x24     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x24     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x24     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x24     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x24     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x24     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x24     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x24     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x24     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x24     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x40 "RIMSC,GPIO Rising Edge Interrupt Mask Set Clear Register"
  bitfld.long        0x40      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x40      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x40      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x40      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x40      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x40      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x40      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x40      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x40      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x40      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x40     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x40     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x40     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x40     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x40     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x40     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x40     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x40     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x40     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x40     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x40     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x40     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x40     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x40     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x40     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x40     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x40     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x40     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x40     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x40     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x40     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x40     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x44 "FIMSC,GPIO Falling Edge Interrupt Mask Set Clear Register"
  bitfld.long        0x44      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x44      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x44      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x44      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x44      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x44      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x44      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x44      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x44      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x44      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x44     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x44     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x44     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x44     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x44     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x44     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x44     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x44     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x44     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x44     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x44     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x44     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x44     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x44     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x44     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x44     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x44     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x44     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x44     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x44     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x44     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x44     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x48 "IS   ,GPIO Interrupt Status Register"
  bitfld.long        0x48      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x48      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x48      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x48      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x48      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x48      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x48      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x48      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x48      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x48      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x48     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x48     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x48     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x48     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x48     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x48     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x48     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x48     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x48     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x48     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x48     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x48     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x48     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x48     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x48     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x48     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x48     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x48     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x48     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x48     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x48     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x48     31.            " p31 ,Pin 31"              "0,1"
 line.long 0x4c "IC   ,GPIO Interrupt Clear Register"
  bitfld.long        0x4c      0.            " p0  ,Pin 0 "              "0,1"
  bitfld.long        0x4c      1.            " p1  ,Pin 1 "              "0,1"
  bitfld.long        0x4c      2.            " p2  ,Pin 2 "              "0,1"
  bitfld.long        0x4c      3.            " p3  ,Pin 3 "              "0,1"
  bitfld.long        0x4c      4.            " p4  ,Pin 4 "              "0,1"
  bitfld.long        0x4c      5.            " p5  ,Pin 5 "              "0,1"
  bitfld.long        0x4c      6.            " p6  ,Pin 6 "              "0,1"
  bitfld.long        0x4c      7.            " p7  ,Pin 7 "              "0,1"
 textline "                 "
  bitfld.long        0x4c      8.            " p8  ,Pin 8 "              "0,1"
  bitfld.long        0x4c      9.            " p9  ,Pin 9 "              "0,1"
  bitfld.long        0x4c     10.            " p10 ,Pin 10"              "0,1"
  bitfld.long        0x4c     11.            " p11 ,Pin 11"              "0,1"
  bitfld.long        0x4c     12.            " p12 ,Pin 12"              "0,1"
  bitfld.long        0x4c     13.            " p13 ,Pin 13"              "0,1"
  bitfld.long        0x4c     14.            " p14 ,Pin 14"              "0,1"
  bitfld.long        0x4c     15.            " p15 ,Pin 15"              "0,1"
 textline "                 "
  bitfld.long        0x4c     16.            " p16 ,Pin 16"              "0,1"
  bitfld.long        0x4c     17.            " p17 ,Pin 17"              "0,1"
  bitfld.long        0x4c     18.            " p18 ,Pin 18"              "0,1"
  bitfld.long        0x4c     19.            " p19 ,Pin 19"              "0,1"
  bitfld.long        0x4c     20.            " p20 ,Pin 20"              "0,1"
  bitfld.long        0x4c     21.            " p21 ,Pin 21"              "0,1"
  bitfld.long        0x4c     22.            " p22 ,Pin 22"              "0,1"
  bitfld.long        0x4c     23.            " p23 ,Pin 23"              "0,1"
 textline "                 "
  bitfld.long        0x4c     24.            " p24 ,Pin 24"              "0,1"
  bitfld.long        0x4c     25.            " p25 ,Pin 25"              "0,1"
  bitfld.long        0x4c     26.            " p26 ,Pin 26"              "0,1"
  bitfld.long        0x4c     27.            " p27 ,Pin 27"              "0,1"
  bitfld.long        0x4c     28.            " p28 ,Pin 28"              "0,1"
  bitfld.long        0x4c     29.            " p29 ,Pin 29"              "0,1"
  bitfld.long        0x4c     30.            " p30 ,Pin 30"              "0,1"
  bitfld.long        0x4c     31.            " p31 ,Pin 31"              "0,1"

group.long sd:0x52009000--0x5200904f "GPIO port 1"
  copy

tree.end

tree.end

;end include file ..\common\arm946.ph

textline ""

